# Auto-Generated by cargo-bitbake 0.3.16-alpha.0
#
inherit cargo

# If this is git based prefer versioned ones if they exist
# DEFAULT_PREFERENCE = "-1"

# how to get librespot could be as easy as but default to a git checkout:
# SRC_URI += "crate://crates.io/librespot/0.5.0-dev"
SRC_URI += "git://github.com/librespot-org/librespot;protocol=https;nobranch=1;branch=dev"
SRCREV = "299b7dec20b45b9fa19a4a46252079e8a8b7a8ba"
S = "${WORKDIR}/git"
CARGO_SRC_DIR = ""
PV:append = ".AUTOINC+299b7dec20"

# please note if you have entries that do not begin with crate://
# you must change them to how that package can be fetched
SRC_URI += " \
    crate://crates.io/addr2line/0.22.0;sha256sum=6e4503c46a5c0c7844e948c9a4d6acd9f50cccb4de1c48eb9e291ea17470c678;addr2line-0.22.0.sha256sum=6e4503c46a5c0c7844e948c9a4d6acd9f50cccb4de1c48eb9e291ea17470c678 \
    crate://crates.io/adler/1.0.2;sha256sum=f26201604c87b1e01bd3d98f8d5d9a8fcbb815e8cedb41ffccbeb4bf593a35fe;adler-1.0.2.sha256sum=f26201604c87b1e01bd3d98f8d5d9a8fcbb815e8cedb41ffccbeb4bf593a35fe \
    crate://crates.io/aes/0.8.4;sha256sum=b169f7a6d4742236a0a00c541b845991d0ac43e546831af1249753ab4c3aa3a0;aes-0.8.4.sha256sum=b169f7a6d4742236a0a00c541b845991d0ac43e546831af1249753ab4c3aa3a0 \
    crate://crates.io/aho-corasick/1.1.3;sha256sum=8e60d3430d3a69478ad0993f19238d2df97c507009a52b3c10addcd7f6bcb916;aho-corasick-1.1.3.sha256sum=8e60d3430d3a69478ad0993f19238d2df97c507009a52b3c10addcd7f6bcb916 \
    crate://crates.io/alsa-sys/0.3.1;sha256sum=db8fee663d06c4e303404ef5f40488a53e062f89ba8bfed81f42325aafad1527;alsa-sys-0.3.1.sha256sum=db8fee663d06c4e303404ef5f40488a53e062f89ba8bfed81f42325aafad1527 \
    crate://crates.io/alsa/0.9.0;sha256sum=37fe60779335388a88c01ac6c3be40304d1e349de3ada3b15f7808bb90fa9dce;alsa-0.9.0.sha256sum=37fe60779335388a88c01ac6c3be40304d1e349de3ada3b15f7808bb90fa9dce \
    crate://crates.io/anstream/0.6.14;sha256sum=418c75fa768af9c03be99d17643f93f79bbba589895012a80e3452a19ddda15b;anstream-0.6.14.sha256sum=418c75fa768af9c03be99d17643f93f79bbba589895012a80e3452a19ddda15b \
    crate://crates.io/anstyle/1.0.7;sha256sum=038dfcf04a5feb68e9c60b21c9625a54c2c0616e79b72b0fd87075a056ae1d1b;anstyle-1.0.7.sha256sum=038dfcf04a5feb68e9c60b21c9625a54c2c0616e79b72b0fd87075a056ae1d1b \
    crate://crates.io/anstyle-parse/0.2.4;sha256sum=c03a11a9034d92058ceb6ee011ce58af4a9bf61491aa7e1e59ecd24bd40d22d4;anstyle-parse-0.2.4.sha256sum=c03a11a9034d92058ceb6ee011ce58af4a9bf61491aa7e1e59ecd24bd40d22d4 \
    crate://crates.io/anstyle-query/1.1.0;sha256sum=ad186efb764318d35165f1758e7dcef3b10628e26d41a44bc5550652e6804391;anstyle-query-1.1.0.sha256sum=ad186efb764318d35165f1758e7dcef3b10628e26d41a44bc5550652e6804391 \
    crate://crates.io/anstyle-wincon/3.0.3;sha256sum=61a38449feb7068f52bb06c12759005cf459ee52bb4adc1d5a7c4322d716fb19;anstyle-wincon-3.0.3.sha256sum=61a38449feb7068f52bb06c12759005cf459ee52bb4adc1d5a7c4322d716fb19 \
    crate://crates.io/anyhow/1.0.86;sha256sum=b3d1d046238990b9cf5bcde22a3fb3584ee5cf65fb2765f454ed428c7a0063da;anyhow-1.0.86.sha256sum=b3d1d046238990b9cf5bcde22a3fb3584ee5cf65fb2765f454ed428c7a0063da \
    crate://crates.io/arrayvec/0.7.4;sha256sum=96d30a06541fbafbc7f82ed10c06164cfbd2c401138f6addd8404629c4b16711;arrayvec-0.7.4.sha256sum=96d30a06541fbafbc7f82ed10c06164cfbd2c401138f6addd8404629c4b16711 \
    crate://crates.io/async-trait/0.1.80;sha256sum=c6fa2087f2753a7da8cc1c0dbfcf89579dd57458e36769de5ac750b4671737ca;async-trait-0.1.80.sha256sum=c6fa2087f2753a7da8cc1c0dbfcf89579dd57458e36769de5ac750b4671737ca \
    crate://crates.io/atomic-waker/1.1.2;sha256sum=1505bd5d3d116872e7271a6d4e16d81d0c8570876c8de68093a09ac269d8aac0;atomic-waker-1.1.2.sha256sum=1505bd5d3d116872e7271a6d4e16d81d0c8570876c8de68093a09ac269d8aac0 \
    crate://crates.io/atomic_refcell/0.1.13;sha256sum=41e67cd8309bbd06cd603a9e693a784ac2e5d1e955f11286e355089fcab3047c;atomic_refcell-0.1.13.sha256sum=41e67cd8309bbd06cd603a9e693a784ac2e5d1e955f11286e355089fcab3047c \
    crate://crates.io/autocfg/1.3.0;sha256sum=0c4b4d0bd25bd0b74681c0ad21497610ce1b7c91b1022cd21c80c6fbdd9476b0;autocfg-1.3.0.sha256sum=0c4b4d0bd25bd0b74681c0ad21497610ce1b7c91b1022cd21c80c6fbdd9476b0 \
    crate://crates.io/backtrace/0.3.72;sha256sum=17c6a35df3749d2e8bb1b7b21a976d82b15548788d2735b9d82f329268f71a11;backtrace-0.3.72.sha256sum=17c6a35df3749d2e8bb1b7b21a976d82b15548788d2735b9d82f329268f71a11 \
    crate://crates.io/base64/0.21.7;sha256sum=9d297deb1925b89f2ccc13d7635fa0714f12c87adce1c75356b39ca9b7178567;base64-0.21.7.sha256sum=9d297deb1925b89f2ccc13d7635fa0714f12c87adce1c75356b39ca9b7178567 \
    crate://crates.io/base64/0.22.1;sha256sum=72b3254f16251a8381aa12e40e3c4d2f0199f8c6508fbecb9d91f575e0fbb8c6;base64-0.22.1.sha256sum=72b3254f16251a8381aa12e40e3c4d2f0199f8c6508fbecb9d91f575e0fbb8c6 \
    crate://crates.io/base64ct/1.6.0;sha256sum=8c3c1a368f70d6cf7302d78f8f7093da241fb8e8807c05cc9e51a125895a6d5b;base64ct-1.6.0.sha256sum=8c3c1a368f70d6cf7302d78f8f7093da241fb8e8807c05cc9e51a125895a6d5b \
    crate://crates.io/bindgen/0.69.4;sha256sum=a00dc851838a2120612785d195287475a3ac45514741da670b735818822129a0;bindgen-0.69.4.sha256sum=a00dc851838a2120612785d195287475a3ac45514741da670b735818822129a0 \
    crate://crates.io/bitflags/1.3.2;sha256sum=bef38d45163c2f1dde094a7dfd33ccf595c92905c8f8f4fdc18d06fb1037718a;bitflags-1.3.2.sha256sum=bef38d45163c2f1dde094a7dfd33ccf595c92905c8f8f4fdc18d06fb1037718a \
    crate://crates.io/bitflags/2.5.0;sha256sum=cf4b9d6a944f767f8e5e0db018570623c85f3d925ac718db4e06d0187adb21c1;bitflags-2.5.0.sha256sum=cf4b9d6a944f767f8e5e0db018570623c85f3d925ac718db4e06d0187adb21c1 \
    crate://crates.io/block-buffer/0.10.4;sha256sum=3078c7629b62d3f0439517fa394996acacc5cbc91c5a20d8c658e77abd503a71;block-buffer-0.10.4.sha256sum=3078c7629b62d3f0439517fa394996acacc5cbc91c5a20d8c658e77abd503a71 \
    crate://crates.io/bumpalo/3.16.0;sha256sum=79296716171880943b8470b5f8d03aa55eb2e645a4874bdbb28adb49162e012c;bumpalo-3.16.0.sha256sum=79296716171880943b8470b5f8d03aa55eb2e645a4874bdbb28adb49162e012c \
    crate://crates.io/bytemuck/1.16.0;sha256sum=78834c15cb5d5efe3452d58b1e8ba890dd62d21907f867f383358198e56ebca5;bytemuck-1.16.0.sha256sum=78834c15cb5d5efe3452d58b1e8ba890dd62d21907f867f383358198e56ebca5 \
    crate://crates.io/byteorder/1.5.0;sha256sum=1fd0f2584146f6f2ef48085050886acf353beff7305ebd1ae69500e27c67f64b;byteorder-1.5.0.sha256sum=1fd0f2584146f6f2ef48085050886acf353beff7305ebd1ae69500e27c67f64b \
    crate://crates.io/bytes/1.6.0;sha256sum=514de17de45fdb8dc022b1a7975556c53c86f9f0aa5f534b98977b171857c2c9;bytes-1.6.0.sha256sum=514de17de45fdb8dc022b1a7975556c53c86f9f0aa5f534b98977b171857c2c9 \
    crate://crates.io/cc/1.0.99;sha256sum=96c51067fd44124faa7f870b4b1c969379ad32b2ba805aa959430ceaa384f695;cc-1.0.99.sha256sum=96c51067fd44124faa7f870b4b1c969379ad32b2ba805aa959430ceaa384f695 \
    crate://crates.io/cesu8/1.1.0;sha256sum=6d43a04d8753f35258c91f8ec639f792891f748a1edbd759cf1dcea3382ad83c;cesu8-1.1.0.sha256sum=6d43a04d8753f35258c91f8ec639f792891f748a1edbd759cf1dcea3382ad83c \
    crate://crates.io/cexpr/0.6.0;sha256sum=6fac387a98bb7c37292057cffc56d62ecb629900026402633ae9160df93a8766;cexpr-0.6.0.sha256sum=6fac387a98bb7c37292057cffc56d62ecb629900026402633ae9160df93a8766 \
    crate://crates.io/cfg-expr/0.15.8;sha256sum=d067ad48b8650848b989a59a86c6c36a995d02d2bf778d45c3c5d57bc2718f02;cfg-expr-0.15.8.sha256sum=d067ad48b8650848b989a59a86c6c36a995d02d2bf778d45c3c5d57bc2718f02 \
    crate://crates.io/cfg-if/1.0.0;sha256sum=baf1de4339761588bc0619e3cbc0120ee582ebb74b53b4efbf79117bd2da40fd;cfg-if-1.0.0.sha256sum=baf1de4339761588bc0619e3cbc0120ee582ebb74b53b4efbf79117bd2da40fd \
    crate://crates.io/cipher/0.4.4;sha256sum=773f3b9af64447d2ce9850330c473515014aa235e6a783b02db81ff39e4a3dad;cipher-0.4.4.sha256sum=773f3b9af64447d2ce9850330c473515014aa235e6a783b02db81ff39e4a3dad \
    crate://crates.io/clang-sys/1.8.1;sha256sum=0b023947811758c97c59bf9d1c188fd619ad4718dcaa767947df1cadb14f39f4;clang-sys-1.8.1.sha256sum=0b023947811758c97c59bf9d1c188fd619ad4718dcaa767947df1cadb14f39f4 \
    crate://crates.io/colorchoice/1.0.1;sha256sum=0b6a852b24ab71dffc585bcb46eaf7959d175cb865a7152e35b348d1b2960422;colorchoice-1.0.1.sha256sum=0b6a852b24ab71dffc585bcb46eaf7959d175cb865a7152e35b348d1b2960422 \
    crate://crates.io/combine/4.6.7;sha256sum=ba5a308b75df32fe02788e748662718f03fde005016435c444eea572398219fd;combine-4.6.7.sha256sum=ba5a308b75df32fe02788e748662718f03fde005016435c444eea572398219fd \
    crate://crates.io/const-oid/0.9.6;sha256sum=c2459377285ad874054d797f3ccebf984978aa39129f6eafde5cdc8315b612f8;const-oid-0.9.6.sha256sum=c2459377285ad874054d797f3ccebf984978aa39129f6eafde5cdc8315b612f8 \
    crate://crates.io/core-foundation-sys/0.8.6;sha256sum=06ea2b9bc92be3c2baa9334a323ebca2d6f074ff852cd1d7b11064035cd3868f;core-foundation-sys-0.8.6.sha256sum=06ea2b9bc92be3c2baa9334a323ebca2d6f074ff852cd1d7b11064035cd3868f \
    crate://crates.io/core-foundation/0.9.4;sha256sum=91e195e091a93c46f7102ec7818a2aa394e1e1771c3ab4825963fa03e45afb8f;core-foundation-0.9.4.sha256sum=91e195e091a93c46f7102ec7818a2aa394e1e1771c3ab4825963fa03e45afb8f \
    crate://crates.io/coreaudio-rs/0.11.3;sha256sum=321077172d79c662f64f5071a03120748d5bb652f5231570141be24cfcd2bace;coreaudio-rs-0.11.3.sha256sum=321077172d79c662f64f5071a03120748d5bb652f5231570141be24cfcd2bace \
    crate://crates.io/coreaudio-sys/0.2.15;sha256sum=7f01585027057ff5f0a5bf276174ae4c1594a2c5bde93d5f46a016d76270f5a9;coreaudio-sys-0.2.15.sha256sum=7f01585027057ff5f0a5bf276174ae4c1594a2c5bde93d5f46a016d76270f5a9 \
    crate://crates.io/cpal/0.15.3;sha256sum=873dab07c8f743075e57f524c583985fbaf745602acbe916a01539364369a779;cpal-0.15.3.sha256sum=873dab07c8f743075e57f524c583985fbaf745602acbe916a01539364369a779 \
    crate://crates.io/cpufeatures/0.2.12;sha256sum=53fe5e26ff1b7aef8bca9c6080520cfb8d9333c7568e1829cef191a9723e5504;cpufeatures-0.2.12.sha256sum=53fe5e26ff1b7aef8bca9c6080520cfb8d9333c7568e1829cef191a9723e5504 \
    crate://crates.io/crypto-common/0.1.6;sha256sum=1bfb12502f3fc46cca1bb51ac28df9d618d813cdc3d2f25b9fe775a34af26bb3;crypto-common-0.1.6.sha256sum=1bfb12502f3fc46cca1bb51ac28df9d618d813cdc3d2f25b9fe775a34af26bb3 \
    crate://crates.io/ctr/0.9.2;sha256sum=0369ee1ad671834580515889b80f2ea915f23b8be8d0daa4bbaf2ac5c7590835;ctr-0.9.2.sha256sum=0369ee1ad671834580515889b80f2ea915f23b8be8d0daa4bbaf2ac5c7590835 \
    crate://crates.io/dasp_sample/0.11.0;sha256sum=0c87e182de0887fd5361989c677c4e8f5000cd9491d6d563161a8f3a5519fc7f;dasp_sample-0.11.0.sha256sum=0c87e182de0887fd5361989c677c4e8f5000cd9491d6d563161a8f3a5519fc7f \
    crate://crates.io/data-encoding/2.6.0;sha256sum=e8566979429cf69b49a5c740c60791108e86440e8be149bbea4fe54d2c32d6e2;data-encoding-2.6.0.sha256sum=e8566979429cf69b49a5c740c60791108e86440e8be149bbea4fe54d2c32d6e2 \
    crate://crates.io/der/0.7.9;sha256sum=f55bf8e7b65898637379c1b74eb1551107c8294ed26d855ceb9fd1a09cfc9bc0;der-0.7.9.sha256sum=f55bf8e7b65898637379c1b74eb1551107c8294ed26d855ceb9fd1a09cfc9bc0 \
    crate://crates.io/deranged/0.3.11;sha256sum=b42b6fa04a440b495c8b04d0e71b707c585f83cb9cb28cf8cd0d976c315e31b4;deranged-0.3.11.sha256sum=b42b6fa04a440b495c8b04d0e71b707c585f83cb9cb28cf8cd0d976c315e31b4 \
    crate://crates.io/digest/0.10.7;sha256sum=9ed9a281f7bc9b7576e61468ba615a66a5c8cfdff42420a70aa82701a3b1e292;digest-0.10.7.sha256sum=9ed9a281f7bc9b7576e61468ba615a66a5c8cfdff42420a70aa82701a3b1e292 \
    crate://crates.io/displaydoc/0.2.4;sha256sum=487585f4d0c6655fe74905e2504d8ad6908e4db67f744eb140876906c2f3175d;displaydoc-0.2.4.sha256sum=487585f4d0c6655fe74905e2504d8ad6908e4db67f744eb140876906c2f3175d \
    crate://crates.io/dns-sd/0.1.3;sha256sum=d748509dea20228f63ba519bf142ce2593396386125b01f5b0d6412dab972087;dns-sd-0.1.3.sha256sum=d748509dea20228f63ba519bf142ce2593396386125b01f5b0d6412dab972087 \
    crate://crates.io/either/1.12.0;sha256sum=3dca9240753cf90908d7e4aac30f630662b02aebaa1b58a3cadabdb23385b58b;either-1.12.0.sha256sum=3dca9240753cf90908d7e4aac30f630662b02aebaa1b58a3cadabdb23385b58b \
    crate://crates.io/encoding_rs/0.8.34;sha256sum=b45de904aa0b010bce2ab45264d0631681847fa7b6f2eaa7dab7619943bc4f59;encoding_rs-0.8.34.sha256sum=b45de904aa0b010bce2ab45264d0631681847fa7b6f2eaa7dab7619943bc4f59 \
    crate://crates.io/env_logger/0.11.2;sha256sum=6c012a26a7f605efc424dd53697843a72be7dc86ad2d01f7814337794a12231d;env_logger-0.11.2.sha256sum=6c012a26a7f605efc424dd53697843a72be7dc86ad2d01f7814337794a12231d \
    crate://crates.io/env_filter/0.1.0;sha256sum=a009aa4810eb158359dda09d0c87378e4bbb89b5a801f016885a4707ba24f7ea;env_filter-0.1.0.sha256sum=a009aa4810eb158359dda09d0c87378e4bbb89b5a801f016885a4707ba24f7ea \
    crate://crates.io/equivalent/1.0.1;sha256sum=5443807d6dff69373d433ab9ef5378ad8df50ca6298caf15de6e52e24aaf54d5;equivalent-1.0.1.sha256sum=5443807d6dff69373d433ab9ef5378ad8df50ca6298caf15de6e52e24aaf54d5 \
    crate://crates.io/errno/0.3.9;sha256sum=534c5cf6194dfab3db3242765c03bbe257cf92f22b38f6bc0c58d59108a820ba;errno-0.3.9.sha256sum=534c5cf6194dfab3db3242765c03bbe257cf92f22b38f6bc0c58d59108a820ba \
    crate://crates.io/fastrand/2.1.0;sha256sum=9fc0510504f03c51ada170672ac806f1f105a88aa97a5281117e1ddc3368e51a;fastrand-2.1.0.sha256sum=9fc0510504f03c51ada170672ac806f1f105a88aa97a5281117e1ddc3368e51a \
    crate://crates.io/fixedbitset/0.4.2;sha256sum=0ce7134b9999ecaf8bcd65542e436736ef32ddca1b3e06094cb6ec5755203b80;fixedbitset-0.4.2.sha256sum=0ce7134b9999ecaf8bcd65542e436736ef32ddca1b3e06094cb6ec5755203b80 \
    crate://crates.io/fnv/1.0.7;sha256sum=3f9eec918d3f24069decb9af1554cad7c880e2da24a9afd88aca000531ab82c1;fnv-1.0.7.sha256sum=3f9eec918d3f24069decb9af1554cad7c880e2da24a9afd88aca000531ab82c1 \
    crate://crates.io/form_urlencoded/1.2.1;sha256sum=e13624c2627564efccf4934284bdd98cbaa14e79b0b5a141218e507b3a823456;form_urlencoded-1.2.1.sha256sum=e13624c2627564efccf4934284bdd98cbaa14e79b0b5a141218e507b3a823456 \
    crate://crates.io/futures-channel/0.3.30;sha256sum=eac8f7d7865dcb88bd4373ab671c8cf4508703796caa2b1985a9ca867b3fcb78;futures-channel-0.3.30.sha256sum=eac8f7d7865dcb88bd4373ab671c8cf4508703796caa2b1985a9ca867b3fcb78 \
    crate://crates.io/futures-core/0.3.30;sha256sum=dfc6580bb841c5a68e9ef15c77ccc837b40a7504914d52e47b8b0e9bbda25a1d;futures-core-0.3.30.sha256sum=dfc6580bb841c5a68e9ef15c77ccc837b40a7504914d52e47b8b0e9bbda25a1d \
    crate://crates.io/futures-executor/0.3.30;sha256sum=a576fc72ae164fca6b9db127eaa9a9dda0d61316034f33a0a0d4eda41f02b01d;futures-executor-0.3.30.sha256sum=a576fc72ae164fca6b9db127eaa9a9dda0d61316034f33a0a0d4eda41f02b01d \
    crate://crates.io/futures-io/0.3.30;sha256sum=a44623e20b9681a318efdd71c299b6b222ed6f231972bfe2f224ebad6311f0c1;futures-io-0.3.30.sha256sum=a44623e20b9681a318efdd71c299b6b222ed6f231972bfe2f224ebad6311f0c1 \
    crate://crates.io/futures-macro/0.3.30;sha256sum=87750cf4b7a4c0625b1529e4c543c2182106e4dedc60a2a6455e00d212c489ac;futures-macro-0.3.30.sha256sum=87750cf4b7a4c0625b1529e4c543c2182106e4dedc60a2a6455e00d212c489ac \
    crate://crates.io/futures-sink/0.3.30;sha256sum=9fb8e00e87438d937621c1c6269e53f536c14d3fbd6a042bb24879e57d474fb5;futures-sink-0.3.30.sha256sum=9fb8e00e87438d937621c1c6269e53f536c14d3fbd6a042bb24879e57d474fb5 \
    crate://crates.io/futures-task/0.3.30;sha256sum=38d84fa142264698cdce1a9f9172cf383a0c82de1bddcf3092901442c4097004;futures-task-0.3.30.sha256sum=38d84fa142264698cdce1a9f9172cf383a0c82de1bddcf3092901442c4097004 \
    crate://crates.io/futures-timer/3.0.3;sha256sum=f288b0a4f20f9a56b5d1da57e2227c661b7b16168e2f72365f57b63326e29b24;futures-timer-3.0.3.sha256sum=f288b0a4f20f9a56b5d1da57e2227c661b7b16168e2f72365f57b63326e29b24 \
    crate://crates.io/futures-util/0.3.30;sha256sum=3d6401deb83407ab3da39eba7e33987a73c3df0c82b4bb5813ee871c19c41d48;futures-util-0.3.30.sha256sum=3d6401deb83407ab3da39eba7e33987a73c3df0c82b4bb5813ee871c19c41d48 \
    crate://crates.io/futures/0.3.30;sha256sum=645c6916888f6cb6350d2550b80fb63e734897a8498abe35cfb732b6487804b0;futures-0.3.30.sha256sum=645c6916888f6cb6350d2550b80fb63e734897a8498abe35cfb732b6487804b0 \
    crate://crates.io/generic-array/0.14.7;sha256sum=85649ca51fd72272d7821adaf274ad91c288277713d9c18820d8499a7ff69e9a;generic-array-0.14.7.sha256sum=85649ca51fd72272d7821adaf274ad91c288277713d9c18820d8499a7ff69e9a \
    crate://crates.io/getopts/0.2.21;sha256sum=14dbbfd5c71d70241ecf9e6f13737f7b5ce823821063188d7e46c41d371eebd5;getopts-0.2.21.sha256sum=14dbbfd5c71d70241ecf9e6f13737f7b5ce823821063188d7e46c41d371eebd5 \
    crate://crates.io/getrandom/0.2.15;sha256sum=c4567c8db10ae91089c99af84c68c38da3ec2f087c3f82960bcdbf3656b6f4d7;getrandom-0.2.15.sha256sum=c4567c8db10ae91089c99af84c68c38da3ec2f087c3f82960bcdbf3656b6f4d7 \
    crate://crates.io/gimli/0.29.0;sha256sum=40ecd4077b5ae9fd2e9e169b102c6c330d0605168eb0e8bf79952b256dbefffd;gimli-0.29.0.sha256sum=40ecd4077b5ae9fd2e9e169b102c6c330d0605168eb0e8bf79952b256dbefffd \
    crate://crates.io/gio-sys/0.19.5;sha256sum=d4bdbef451b0f0361e7f762987cc6bebd5facab1d535e85a3cf1115dfb08db40;gio-sys-0.19.5.sha256sum=d4bdbef451b0f0361e7f762987cc6bebd5facab1d535e85a3cf1115dfb08db40 \
    crate://crates.io/glib-macros/0.19.7;sha256sum=70025dbfa1275cf7d0531c3317ba6270dae15d87e63342229d638246ff45202e;glib-macros-0.19.7.sha256sum=70025dbfa1275cf7d0531c3317ba6270dae15d87e63342229d638246ff45202e \
    crate://crates.io/glib-sys/0.19.5;sha256sum=767d23ead9bbdfcbb1c2242c155c8128a7d13dde7bf69c176f809546135e2282;glib-sys-0.19.5.sha256sum=767d23ead9bbdfcbb1c2242c155c8128a7d13dde7bf69c176f809546135e2282 \
    crate://crates.io/glib/0.19.7;sha256sum=e52355166df21c7ed16b6a01f615669c7911ed74e27ef60eba339c0d2da12490;glib-0.19.7.sha256sum=e52355166df21c7ed16b6a01f615669c7911ed74e27ef60eba339c0d2da12490 \
    crate://crates.io/glob/0.3.1;sha256sum=d2fabcfbdc87f4758337ca535fb41a6d701b65693ce38287d856d1674551ec9b;glob-0.3.1.sha256sum=d2fabcfbdc87f4758337ca535fb41a6d701b65693ce38287d856d1674551ec9b \
    crate://crates.io/gobject-sys/0.19.5;sha256sum=c3787b0bfacca12bb25f8f822b0dbee9f7e4a86e6469a29976d332d2c14c945b;gobject-sys-0.19.5.sha256sum=c3787b0bfacca12bb25f8f822b0dbee9f7e4a86e6469a29976d332d2c14c945b \
    crate://crates.io/governor/0.6.3;sha256sum=68a7f542ee6b35af73b06abc0dad1c1bae89964e4e253bc4b587b91c9637867b;governor-0.6.3.sha256sum=68a7f542ee6b35af73b06abc0dad1c1bae89964e4e253bc4b587b91c9637867b \
    crate://crates.io/gstreamer-app-sys/0.22.5;sha256sum=5da6c85b35835fa484e1bd554830c6e724c99a7a7fcd0208ff1663c3c6d3c9cd;gstreamer-app-sys-0.22.5.sha256sum=5da6c85b35835fa484e1bd554830c6e724c99a7a7fcd0208ff1663c3c6d3c9cd \
    crate://crates.io/gstreamer-app/0.22.0;sha256sum=50184e88d3462a796a5924fb329839c102b22f9383c1636323fa4ef5255dea92;gstreamer-app-0.22.0.sha256sum=50184e88d3462a796a5924fb329839c102b22f9383c1636323fa4ef5255dea92 \
    crate://crates.io/gstreamer-audio-sys/0.22.5;sha256sum=2dfb1c22539b9b31fde5513fd68e2f0edeeaa5591d92daaaadbfa392736e820f;gstreamer-audio-sys-0.22.5.sha256sum=2dfb1c22539b9b31fde5513fd68e2f0edeeaa5591d92daaaadbfa392736e820f \
    crate://crates.io/gstreamer-audio/0.22.5;sha256sum=703e65074d4f5dce207e855d8f36697ec93f953e5412780dcffc70cb5483337e;gstreamer-audio-0.22.5.sha256sum=703e65074d4f5dce207e855d8f36697ec93f953e5412780dcffc70cb5483337e \
    crate://crates.io/gstreamer-base-sys/0.22.5;sha256sum=2d8d11de9d94072657f2e9ca294b72326874a1e53de9f45613a9bf00773a5938;gstreamer-base-sys-0.22.5.sha256sum=2d8d11de9d94072657f2e9ca294b72326874a1e53de9f45613a9bf00773a5938 \
    crate://crates.io/gstreamer-base/0.22.0;sha256sum=514c71195b53c7eced4842b66ca9149833e41cf6a1d949e45e2ca4a4fa929850;gstreamer-base-0.22.0.sha256sum=514c71195b53c7eced4842b66ca9149833e41cf6a1d949e45e2ca4a4fa929850 \
    crate://crates.io/gstreamer-sys/0.22.5;sha256sum=4975a75279a9cf658bac1798dcf57100c6ec89fca7886572c8250ea4d94b76bd;gstreamer-sys-0.22.5.sha256sum=4975a75279a9cf658bac1798dcf57100c6ec89fca7886572c8250ea4d94b76bd \
    crate://crates.io/gstreamer/0.22.5;sha256sum=56b59fdce2dfacda226d4b1b71ce4700b2f04228909b52252c197d8e30bd54a6;gstreamer-0.22.5.sha256sum=56b59fdce2dfacda226d4b1b71ce4700b2f04228909b52252c197d8e30bd54a6 \
    crate://crates.io/h2/0.4.5;sha256sum=fa82e28a107a8cc405f0839610bdc9b15f1e25ec7d696aa5cf173edbcb1486ab;h2-0.4.5.sha256sum=fa82e28a107a8cc405f0839610bdc9b15f1e25ec7d696aa5cf173edbcb1486ab \
    crate://crates.io/hashbrown/0.12.3;sha256sum=8a9ee70c43aaf417c914396645a0fa852624801b24ebb7ae78fe8272889ac888;hashbrown-0.12.3.sha256sum=8a9ee70c43aaf417c914396645a0fa852624801b24ebb7ae78fe8272889ac888 \
    crate://crates.io/hashbrown/0.14.5;sha256sum=e5274423e17b7c9fc20b6e7e208532f9b19825d82dfd615708b70edd83df41f1;hashbrown-0.14.5.sha256sum=e5274423e17b7c9fc20b6e7e208532f9b19825d82dfd615708b70edd83df41f1 \
    crate://crates.io/headers-core/0.3.0;sha256sum=54b4a22553d4242c49fddb9ba998a99962b5cc6f22cb5a3482bec22522403ce4;headers-core-0.3.0.sha256sum=54b4a22553d4242c49fddb9ba998a99962b5cc6f22cb5a3482bec22522403ce4 \
    crate://crates.io/headers/0.4.0;sha256sum=322106e6bd0cba2d5ead589ddb8150a13d7c4217cf80d7c4f682ca994ccc6aa9;headers-0.4.0.sha256sum=322106e6bd0cba2d5ead589ddb8150a13d7c4217cf80d7c4f682ca994ccc6aa9 \
    crate://crates.io/heck/0.5.0;sha256sum=2304e00983f87ffb38b55b444b5e3b60a884b5d30c0fca7d82fe33449bbe55ea;heck-0.5.0.sha256sum=2304e00983f87ffb38b55b444b5e3b60a884b5d30c0fca7d82fe33449bbe55ea \
    crate://crates.io/hermit-abi/0.3.9;sha256sum=d231dfb89cfffdbc30e7fc41579ed6066ad03abda9e567ccafae602b97ec5024;hermit-abi-0.3.9.sha256sum=d231dfb89cfffdbc30e7fc41579ed6066ad03abda9e567ccafae602b97ec5024 \
    crate://crates.io/hex/0.4.3;sha256sum=7f24254aa9a54b5c858eaee2f5bccdb46aaf0e486a595ed5fd8f86ba55232a70;hex-0.4.3.sha256sum=7f24254aa9a54b5c858eaee2f5bccdb46aaf0e486a595ed5fd8f86ba55232a70 \
    crate://crates.io/hmac/0.12.1;sha256sum=6c49c37c09c17a53d937dfbb742eb3a961d65a994e6bcdcf37e7399d0cc8ab5e;hmac-0.12.1.sha256sum=6c49c37c09c17a53d937dfbb742eb3a961d65a994e6bcdcf37e7399d0cc8ab5e \
    crate://crates.io/home/0.5.9;sha256sum=e3d1354bf6b7235cb4a0576c2619fd4ed18183f689b12b006a0ee7329eeff9a5;home-0.5.9.sha256sum=e3d1354bf6b7235cb4a0576c2619fd4ed18183f689b12b006a0ee7329eeff9a5 \
    crate://crates.io/hostname/0.3.1;sha256sum=3c731c3e10504cc8ed35cfe2f1db4c9274c3d35fa486e3b31df46f068ef3e867;hostname-0.3.1.sha256sum=3c731c3e10504cc8ed35cfe2f1db4c9274c3d35fa486e3b31df46f068ef3e867 \
    crate://crates.io/http-body-util/0.1.2;sha256sum=793429d76616a256bcb62c2a2ec2bed781c8307e797e2598c50010f2bee2544f;http-body-util-0.1.2.sha256sum=793429d76616a256bcb62c2a2ec2bed781c8307e797e2598c50010f2bee2544f \
    crate://crates.io/http-body/1.0.0;sha256sum=1cac85db508abc24a2e48553ba12a996e87244a0395ce011e62b37158745d643;http-body-1.0.0.sha256sum=1cac85db508abc24a2e48553ba12a996e87244a0395ce011e62b37158745d643 \
    crate://crates.io/http/1.1.0;sha256sum=21b9ddb458710bc376481b842f5da65cdf31522de232c1ca8146abce2a358258;http-1.1.0.sha256sum=21b9ddb458710bc376481b842f5da65cdf31522de232c1ca8146abce2a358258 \
    crate://crates.io/httparse/1.9.2;sha256sum=9f3935c160d00ac752e09787e6e6bfc26494c2183cc922f1bc678a60d4733bc2;httparse-1.9.2.sha256sum=9f3935c160d00ac752e09787e6e6bfc26494c2183cc922f1bc678a60d4733bc2 \
    crate://crates.io/httpdate/1.0.3;sha256sum=df3b46402a9d5adb4c86a0cf463f42e19994e3ee891101b1841f30a545cb49a9;httpdate-1.0.3.sha256sum=df3b46402a9d5adb4c86a0cf463f42e19994e3ee891101b1841f30a545cb49a9 \
    crate://crates.io/humantime/2.1.0;sha256sum=9a3a5bfb195931eeb336b2a7b4d761daec841b97f947d34394601737a7bba5e4;humantime-2.1.0.sha256sum=9a3a5bfb195931eeb336b2a7b4d761daec841b97f947d34394601737a7bba5e4 \
    crate://crates.io/hyper-proxy2/0.1.0;sha256sum=9043b7b23fb0bc4a1c7014c27b50a4fc42cc76206f71d34fc0dfe5b28ddc3faf;hyper-proxy2-0.1.0.sha256sum=9043b7b23fb0bc4a1c7014c27b50a4fc42cc76206f71d34fc0dfe5b28ddc3faf \
    crate://crates.io/hyper-rustls/0.26.0;sha256sum=a0bea761b46ae2b24eb4aef630d8d1c398157b6fc29e6350ecf090a0b70c952c;hyper-rustls-0.26.0.sha256sum=a0bea761b46ae2b24eb4aef630d8d1c398157b6fc29e6350ecf090a0b70c952c \
    crate://crates.io/hyper-util/0.1.5;sha256sum=7b875924a60b96e5d7b9ae7b066540b1dd1cbd90d1828f54c92e02a283351c56;hyper-util-0.1.5.sha256sum=7b875924a60b96e5d7b9ae7b066540b1dd1cbd90d1828f54c92e02a283351c56 \
    crate://crates.io/hyper/1.3.1;sha256sum=fe575dd17d0862a9a33781c8c4696a55c320909004a67a00fb286ba8b1bc496d;hyper-1.3.1.sha256sum=fe575dd17d0862a9a33781c8c4696a55c320909004a67a00fb286ba8b1bc496d \
    crate://crates.io/icu_collections/1.5.0;sha256sum=db2fa452206ebee18c4b5c2274dbf1de17008e874b4dc4f0aea9d01ca79e4526;icu_collections-1.5.0.sha256sum=db2fa452206ebee18c4b5c2274dbf1de17008e874b4dc4f0aea9d01ca79e4526 \
    crate://crates.io/icu_locid/1.5.0;sha256sum=13acbb8371917fc971be86fc8057c41a64b521c184808a698c02acc242dbf637;icu_locid-1.5.0.sha256sum=13acbb8371917fc971be86fc8057c41a64b521c184808a698c02acc242dbf637 \
    crate://crates.io/icu_locid_transform/1.5.0;sha256sum=01d11ac35de8e40fdeda00d9e1e9d92525f3f9d887cdd7aa81d727596788b54e;icu_locid_transform-1.5.0.sha256sum=01d11ac35de8e40fdeda00d9e1e9d92525f3f9d887cdd7aa81d727596788b54e \
    crate://crates.io/icu_locid_transform_data/1.5.0;sha256sum=fdc8ff3388f852bede6b579ad4e978ab004f139284d7b28715f773507b946f6e;icu_locid_transform_data-1.5.0.sha256sum=fdc8ff3388f852bede6b579ad4e978ab004f139284d7b28715f773507b946f6e \
    crate://crates.io/icu_normalizer/1.5.0;sha256sum=19ce3e0da2ec68599d193c93d088142efd7f9c5d6fc9b803774855747dc6a84f;icu_normalizer-1.5.0.sha256sum=19ce3e0da2ec68599d193c93d088142efd7f9c5d6fc9b803774855747dc6a84f \
    crate://crates.io/icu_normalizer_data/1.5.0;sha256sum=f8cafbf7aa791e9b22bec55a167906f9e1215fd475cd22adfcf660e03e989516;icu_normalizer_data-1.5.0.sha256sum=f8cafbf7aa791e9b22bec55a167906f9e1215fd475cd22adfcf660e03e989516 \
    crate://crates.io/icu_properties/1.5.0;sha256sum=1f8ac670d7422d7f76b32e17a5db556510825b29ec9154f235977c9caba61036;icu_properties-1.5.0.sha256sum=1f8ac670d7422d7f76b32e17a5db556510825b29ec9154f235977c9caba61036 \
    crate://crates.io/icu_properties_data/1.5.0;sha256sum=67a8effbc3dd3e4ba1afa8ad918d5684b8868b3b26500753effea8d2eed19569;icu_properties_data-1.5.0.sha256sum=67a8effbc3dd3e4ba1afa8ad918d5684b8868b3b26500753effea8d2eed19569 \
    crate://crates.io/icu_provider/1.5.0;sha256sum=6ed421c8a8ef78d3e2dbc98a973be2f3770cb42b606e3ab18d6237c4dfde68d9;icu_provider-1.5.0.sha256sum=6ed421c8a8ef78d3e2dbc98a973be2f3770cb42b606e3ab18d6237c4dfde68d9 \
    crate://crates.io/icu_provider_macros/1.5.0;sha256sum=1ec89e9337638ecdc08744df490b221a7399bf8d164eb52a665454e60e075ad6;icu_provider_macros-1.5.0.sha256sum=1ec89e9337638ecdc08744df490b221a7399bf8d164eb52a665454e60e075ad6 \
    crate://crates.io/idna/1.0.0;sha256sum=4716a3a0933a1d01c2f72450e89596eb51dd34ef3c211ccd875acdf1f8fe47ed;idna-1.0.0.sha256sum=4716a3a0933a1d01c2f72450e89596eb51dd34ef3c211ccd875acdf1f8fe47ed \
    crate://crates.io/if-addrs/0.11.1;sha256sum=624c5448ba529e74f594c65b7024f31b2de7b64a9b228b8df26796bbb6e32c36;if-addrs-0.11.1.sha256sum=624c5448ba529e74f594c65b7024f31b2de7b64a9b228b8df26796bbb6e32c36 \
    crate://crates.io/indexmap/1.9.3;sha256sum=bd070e393353796e801d209ad339e89596eb4c8d430d18ede6a1cced8fafbd99;indexmap-1.9.3.sha256sum=bd070e393353796e801d209ad339e89596eb4c8d430d18ede6a1cced8fafbd99 \
    crate://crates.io/indexmap/2.2.6;sha256sum=168fb715dda47215e360912c096649d23d58bf392ac62f73919e831745e40f26;indexmap-2.2.6.sha256sum=168fb715dda47215e360912c096649d23d58bf392ac62f73919e831745e40f26 \
    crate://crates.io/inout/0.1.3;sha256sum=a0c10553d664a4d0bcff9f4215d0aac67a639cc68ef660840afe309b807bc9f5;inout-0.1.3.sha256sum=a0c10553d664a4d0bcff9f4215d0aac67a639cc68ef660840afe309b807bc9f5 \
    crate://crates.io/itertools/0.12.1;sha256sum=ba291022dbbd398a455acf126c1e341954079855bc60dfdda641363bd6922569;itertools-0.12.1.sha256sum=ba291022dbbd398a455acf126c1e341954079855bc60dfdda641363bd6922569 \
    crate://crates.io/itertools/0.13.0;sha256sum=413ee7dfc52ee1a4949ceeb7dbc8a33f2d6c088194d9f922fb8318faf1f01186;itertools-0.13.0.sha256sum=413ee7dfc52ee1a4949ceeb7dbc8a33f2d6c088194d9f922fb8318faf1f01186 \
    crate://crates.io/itoa/1.0.11;sha256sum=49f1f14873335454500d59611f1cf4a4b0f786f9ac11f4312a78e4cf2566695b;itoa-1.0.11.sha256sum=49f1f14873335454500d59611f1cf4a4b0f786f9ac11f4312a78e4cf2566695b \
    crate://crates.io/is_terminal_polyfill/1.70.0;sha256sum=f8478577c03552c21db0e2724ffb8986a5ce7af88107e6be5d2ee6e158c12800;is_terminal_polyfill-1.70.0.sha256sum=f8478577c03552c21db0e2724ffb8986a5ce7af88107e6be5d2ee6e158c12800 \
    crate://crates.io/jack-sys/0.5.1;sha256sum=6013b7619b95a22b576dfb43296faa4ecbe40abbdb97dfd22ead520775fc86ab;jack-sys-0.5.1.sha256sum=6013b7619b95a22b576dfb43296faa4ecbe40abbdb97dfd22ead520775fc86ab \
    crate://crates.io/jack/0.11.4;sha256sum=0e5a18a3c2aefb354fb77111ade228b20267bdc779de84e7a4ccf7ea96b9a6cd;jack-0.11.4.sha256sum=0e5a18a3c2aefb354fb77111ade228b20267bdc779de84e7a4ccf7ea96b9a6cd \
    crate://crates.io/jni-sys/0.3.0;sha256sum=8eaf4bc02d17cbdd7ff4c7438cafcdf7fb9a4613313ad11b4f8fefe7d3fa0130;jni-sys-0.3.0.sha256sum=8eaf4bc02d17cbdd7ff4c7438cafcdf7fb9a4613313ad11b4f8fefe7d3fa0130 \
    crate://crates.io/jni/0.21.1;sha256sum=1a87aa2bb7d2af34197c04845522473242e1aa17c12f4935d5856491a7fb8c97;jni-0.21.1.sha256sum=1a87aa2bb7d2af34197c04845522473242e1aa17c12f4935d5856491a7fb8c97 \
    crate://crates.io/jobserver/0.1.31;sha256sum=d2b099aaa34a9751c5bf0878add70444e1ed2dd73f347be99003d4577277de6e;jobserver-0.1.31.sha256sum=d2b099aaa34a9751c5bf0878add70444e1ed2dd73f347be99003d4577277de6e \
    crate://crates.io/js-sys/0.3.69;sha256sum=29c15563dc2726973df627357ce0c9ddddbea194836909d655df6a75d2cf296d;js-sys-0.3.69.sha256sum=29c15563dc2726973df627357ce0c9ddddbea194836909d655df6a75d2cf296d \
    crate://crates.io/lazy_static/1.4.0;sha256sum=e2abad23fbc42b3700f2f279844dc832adb2b2eb069b2df918f455c4e18cc646;lazy_static-1.4.0.sha256sum=e2abad23fbc42b3700f2f279844dc832adb2b2eb069b2df918f455c4e18cc646 \
    crate://crates.io/lazycell/1.3.0;sha256sum=830d08ce1d1d941e6b30645f1a0eb5643013d835ce3779a5fc208261dbe10f55;lazycell-1.3.0.sha256sum=830d08ce1d1d941e6b30645f1a0eb5643013d835ce3779a5fc208261dbe10f55 \
    crate://crates.io/libc/0.2.155;sha256sum=97b3888a4aecf77e811145cadf6eef5901f4782c53886191b2f693f24761847c;libc-0.2.155.sha256sum=97b3888a4aecf77e811145cadf6eef5901f4782c53886191b2f693f24761847c \
    crate://crates.io/libloading/0.7.4;sha256sum=b67380fd3b2fbe7527a606e18729d21c6f3951633d0500574c4dc22d2d638b9f;libloading-0.7.4.sha256sum=b67380fd3b2fbe7527a606e18729d21c6f3951633d0500574c4dc22d2d638b9f \
    crate://crates.io/libloading/0.8.3;sha256sum=0c2a198fb6b0eada2a8df47933734e6d35d350665a33a3593d7164fa52c75c19;libloading-0.8.3.sha256sum=0c2a198fb6b0eada2a8df47933734e6d35d350665a33a3593d7164fa52c75c19 \
    crate://crates.io/libm/0.2.8;sha256sum=4ec2a862134d2a7d32d7983ddcdd1c4923530833c9f2ea1a44fc5fa473989058;libm-0.2.8.sha256sum=4ec2a862134d2a7d32d7983ddcdd1c4923530833c9f2ea1a44fc5fa473989058 \
    crate://crates.io/libmdns/0.8.0;sha256sum=8ed6677a7ef3e8d47432fc827d0ebf0ee77c3e3bc4a3e632d9b92433ef86f70c;libmdns-0.8.0.sha256sum=8ed6677a7ef3e8d47432fc827d0ebf0ee77c3e3bc4a3e632d9b92433ef86f70c \
    crate://crates.io/libpulse-binding/2.28.1;sha256sum=ed3557a2dfc380c8f061189a01c6ae7348354e0c9886038dc6c171219c08eaff;libpulse-binding-2.28.1.sha256sum=ed3557a2dfc380c8f061189a01c6ae7348354e0c9886038dc6c171219c08eaff \
    crate://crates.io/libpulse-simple-binding/2.28.1;sha256sum=05fd6b68f33f6a251265e6ed1212dc3107caad7c5c6fdcd847b2e65ef58c308d;libpulse-simple-binding-2.28.1.sha256sum=05fd6b68f33f6a251265e6ed1212dc3107caad7c5c6fdcd847b2e65ef58c308d \
    crate://crates.io/libpulse-simple-sys/1.21.1;sha256sum=ea6613b4199d8b9f0edcfb623e020cb17bbd0bee8dd21f3c7cc938de561c4152;libpulse-simple-sys-1.21.1.sha256sum=ea6613b4199d8b9f0edcfb623e020cb17bbd0bee8dd21f3c7cc938de561c4152 \
    crate://crates.io/libpulse-sys/1.21.0;sha256sum=bc19e110fbf42c17260d30f6d3dc545f58491c7830d38ecb9aaca96e26067a9b;libpulse-sys-1.21.0.sha256sum=bc19e110fbf42c17260d30f6d3dc545f58491c7830d38ecb9aaca96e26067a9b \
    crate://crates.io/linux-raw-sys/0.4.14;sha256sum=78b3ae25bc7c8c38cec158d1f2757ee79e9b3740fbc7ccf0e59e4b08d793fa89;linux-raw-sys-0.4.14.sha256sum=78b3ae25bc7c8c38cec158d1f2757ee79e9b3740fbc7ccf0e59e4b08d793fa89 \
    crate://crates.io/litemap/0.7.3;sha256sum=643cb0b8d4fcc284004d5fd0d67ccf61dfffadb7f75e1e71bc420f4688a3a704;litemap-0.7.3.sha256sum=643cb0b8d4fcc284004d5fd0d67ccf61dfffadb7f75e1e71bc420f4688a3a704 \
    crate://crates.io/lock_api/0.4.12;sha256sum=07af8b9cdd281b7915f413fa73f29ebd5d55d0d3f0155584dade1ff18cea1b17;lock_api-0.4.12.sha256sum=07af8b9cdd281b7915f413fa73f29ebd5d55d0d3f0155584dade1ff18cea1b17 \
    crate://crates.io/log/0.4.21;sha256sum=90ed8c1e510134f979dbc4f070f87d4313098b704861a105fe34231c70a3901c;log-0.4.21.sha256sum=90ed8c1e510134f979dbc4f070f87d4313098b704861a105fe34231c70a3901c \
    crate://crates.io/mach2/0.4.2;sha256sum=19b955cdeb2a02b9117f121ce63aa52d08ade45de53e48fe6a38b39c10f6f709;mach2-0.4.2.sha256sum=19b955cdeb2a02b9117f121ce63aa52d08ade45de53e48fe6a38b39c10f6f709 \
    crate://crates.io/match_cfg/0.1.0;sha256sum=ffbee8634e0d45d258acb448e7eaab3fce7a0a467395d4d9f228e3c1f01fb2e4;match_cfg-0.1.0.sha256sum=ffbee8634e0d45d258acb448e7eaab3fce7a0a467395d4d9f228e3c1f01fb2e4 \
    crate://crates.io/memchr/2.7.2;sha256sum=6c8640c5d730cb13ebd907d8d04b52f55ac9a2eec55b440c8892f40d56c76c1d;memchr-2.7.2.sha256sum=6c8640c5d730cb13ebd907d8d04b52f55ac9a2eec55b440c8892f40d56c76c1d \
    crate://crates.io/memoffset/0.9.1;sha256sum=488016bfae457b036d996092f6cb448677611ce4449e970ceaf42695203f218a;memoffset-0.9.1.sha256sum=488016bfae457b036d996092f6cb448677611ce4449e970ceaf42695203f218a \
    crate://crates.io/mime/0.3.17;sha256sum=6877bb514081ee2a7ff5ef9de3281f14a4dd4bceac4c09388074a6b5df8a139a;mime-0.3.17.sha256sum=6877bb514081ee2a7ff5ef9de3281f14a4dd4bceac4c09388074a6b5df8a139a \
    crate://crates.io/minimal-lexical/0.2.1;sha256sum=68354c5c6bd36d73ff3feceb05efa59b6acb7626617f4962be322a825e61f79a;minimal-lexical-0.2.1.sha256sum=68354c5c6bd36d73ff3feceb05efa59b6acb7626617f4962be322a825e61f79a \
    crate://crates.io/miniz_oxide/0.7.3;sha256sum=87dfd01fe195c66b572b37921ad8803d010623c0aca821bea2302239d155cdae;miniz_oxide-0.7.3.sha256sum=87dfd01fe195c66b572b37921ad8803d010623c0aca821bea2302239d155cdae \
    crate://crates.io/mio/0.8.11;sha256sum=a4a650543ca06a924e8b371db273b2756685faae30f8487da1b56505a8f78b0c;mio-0.8.11.sha256sum=a4a650543ca06a924e8b371db273b2756685faae30f8487da1b56505a8f78b0c \
    crate://crates.io/muldiv/1.0.1;sha256sum=956787520e75e9bd233246045d19f42fb73242759cc57fba9611d940ae96d4b0;muldiv-1.0.1.sha256sum=956787520e75e9bd233246045d19f42fb73242759cc57fba9611d940ae96d4b0 \
    crate://crates.io/multimap/0.9.1;sha256sum=e1a5d38b9b352dbd913288736af36af41c48d61b1a8cd34bcecd727561b7d511;multimap-0.9.1.sha256sum=e1a5d38b9b352dbd913288736af36af41c48d61b1a8cd34bcecd727561b7d511 \
    crate://crates.io/ndk-context/0.1.1;sha256sum=27b02d87554356db9e9a873add8782d4ea6e3e58ea071a9adb9a2e8ddb884a8b;ndk-context-0.1.1.sha256sum=27b02d87554356db9e9a873add8782d4ea6e3e58ea071a9adb9a2e8ddb884a8b \
    crate://crates.io/ndk-sys/0.5.0+25.2.9519653;sha256sum=8c196769dd60fd4f363e11d948139556a344e79d451aeb2fa2fd040738ef7691;ndk-sys-0.5.0+25.2.9519653.sha256sum=8c196769dd60fd4f363e11d948139556a344e79d451aeb2fa2fd040738ef7691 \
    crate://crates.io/ndk/0.8.0;sha256sum=2076a31b7010b17a38c01907c45b945e8f11495ee4dd588309718901b1f7a5b7;ndk-0.8.0.sha256sum=2076a31b7010b17a38c01907c45b945e8f11495ee4dd588309718901b1f7a5b7 \
    crate://crates.io/nix/0.27.1;sha256sum=2eb04e9c688eff1c89d72b407f168cf79bb9e867a9d3323ed6c01519eb9cc053;nix-0.27.1.sha256sum=2eb04e9c688eff1c89d72b407f168cf79bb9e867a9d3323ed6c01519eb9cc053 \
    crate://crates.io/no-std-compat/0.4.1;sha256sum=b93853da6d84c2e3c7d730d6473e8817692dd89be387eb01b94d7f108ecb5b8c;no-std-compat-0.4.1.sha256sum=b93853da6d84c2e3c7d730d6473e8817692dd89be387eb01b94d7f108ecb5b8c \
    crate://crates.io/nom/7.1.3;sha256sum=d273983c5a657a70a3e8f2a01329822f3b8c8172b73826411a55751e404a0a4a;nom-7.1.3.sha256sum=d273983c5a657a70a3e8f2a01329822f3b8c8172b73826411a55751e404a0a4a \
    crate://crates.io/nonzero_ext/0.3.0;sha256sum=38bf9645c8b145698bb0b18a4637dcacbc421ea49bef2317e4fd8065a387cf21;nonzero_ext-0.3.0.sha256sum=38bf9645c8b145698bb0b18a4637dcacbc421ea49bef2317e4fd8065a387cf21 \
    crate://crates.io/ntapi/0.4.1;sha256sum=e8a3895c6391c39d7fe7ebc444a87eb2991b2a0bc718fdabd071eec617fc68e4;ntapi-0.4.1.sha256sum=e8a3895c6391c39d7fe7ebc444a87eb2991b2a0bc718fdabd071eec617fc68e4 \
    crate://crates.io/num-bigint-dig/0.8.4;sha256sum=dc84195820f291c7697304f3cbdadd1cb7199c0efc917ff5eafd71225c136151;num-bigint-dig-0.8.4.sha256sum=dc84195820f291c7697304f3cbdadd1cb7199c0efc917ff5eafd71225c136151 \
    crate://crates.io/num-bigint/0.4.5;sha256sum=c165a9ab64cf766f73521c0dd2cfdff64f488b8f0b3e621face3462d3db536d7;num-bigint-0.4.5.sha256sum=c165a9ab64cf766f73521c0dd2cfdff64f488b8f0b3e621face3462d3db536d7 \
    crate://crates.io/num-conv/0.1.0;sha256sum=51d515d32fb182ee37cda2ccdcb92950d6a3c2893aa280e540671c2cd0f3b1d9;num-conv-0.1.0.sha256sum=51d515d32fb182ee37cda2ccdcb92950d6a3c2893aa280e540671c2cd0f3b1d9 \
    crate://crates.io/num-derive/0.3.3;sha256sum=876a53fff98e03a936a674b29568b0e605f06b29372c2489ff4de23f1949743d;num-derive-0.3.3.sha256sum=876a53fff98e03a936a674b29568b0e605f06b29372c2489ff4de23f1949743d \
    crate://crates.io/num-derive/0.4.2;sha256sum=ed3955f1a9c7c0c15e092f9c887db08b1fc683305fdf6eb6684f22555355e202;num-derive-0.4.2.sha256sum=ed3955f1a9c7c0c15e092f9c887db08b1fc683305fdf6eb6684f22555355e202 \
    crate://crates.io/num-integer/0.1.46;sha256sum=7969661fd2958a5cb096e56c8e1ad0444ac2bbcd0061bd28660485a44879858f;num-integer-0.1.46.sha256sum=7969661fd2958a5cb096e56c8e1ad0444ac2bbcd0061bd28660485a44879858f \
    crate://crates.io/num-iter/0.1.45;sha256sum=1429034a0490724d0075ebb2bc9e875d6503c3cf69e235a8941aa757d83ef5bf;num-iter-0.1.45.sha256sum=1429034a0490724d0075ebb2bc9e875d6503c3cf69e235a8941aa757d83ef5bf \
    crate://crates.io/num-rational/0.4.2;sha256sum=f83d14da390562dca69fc84082e73e548e1ad308d24accdedd2720017cb37824;num-rational-0.4.2.sha256sum=f83d14da390562dca69fc84082e73e548e1ad308d24accdedd2720017cb37824 \
    crate://crates.io/num-traits/0.2.19;sha256sum=071dfc062690e90b734c0b2273ce72ad0ffa95f0c74596bc250dcfd960262841;num-traits-0.2.19.sha256sum=071dfc062690e90b734c0b2273ce72ad0ffa95f0c74596bc250dcfd960262841 \
    crate://crates.io/num_cpus/1.16.0;sha256sum=4161fcb6d602d4d2081af7c3a45852d875a03dd337a6bfdd6e06407b61342a43;num_cpus-1.16.0.sha256sum=4161fcb6d602d4d2081af7c3a45852d875a03dd337a6bfdd6e06407b61342a43 \
    crate://crates.io/num_enum/0.7.2;sha256sum=02339744ee7253741199f897151b38e72257d13802d4ee837285cc2990a90845;num_enum-0.7.2.sha256sum=02339744ee7253741199f897151b38e72257d13802d4ee837285cc2990a90845 \
    crate://crates.io/num_enum_derive/0.7.2;sha256sum=681030a937600a36906c185595136d26abfebb4aa9c65701cefcaf8578bb982b;num_enum_derive-0.7.2.sha256sum=681030a937600a36906c185595136d26abfebb4aa9c65701cefcaf8578bb982b \
    crate://crates.io/num_threads/0.1.7;sha256sum=5c7398b9c8b70908f6371f47ed36737907c87c52af34c268fed0bf0ceb92ead9;num_threads-0.1.7.sha256sum=5c7398b9c8b70908f6371f47ed36737907c87c52af34c268fed0bf0ceb92ead9 \
    crate://crates.io/object/0.35.0;sha256sum=b8ec7ab813848ba4522158d5517a6093db1ded27575b070f4177b8d12b41db5e;object-0.35.0.sha256sum=b8ec7ab813848ba4522158d5517a6093db1ded27575b070f4177b8d12b41db5e \
    crate://crates.io/oboe-sys/0.6.1;sha256sum=6c8bb09a4a2b1d668170cfe0a7d5bc103f8999fb316c98099b6a9939c9f2e79d;oboe-sys-0.6.1.sha256sum=6c8bb09a4a2b1d668170cfe0a7d5bc103f8999fb316c98099b6a9939c9f2e79d \
    crate://crates.io/oboe/0.6.1;sha256sum=e8b61bebd49e5d43f5f8cc7ee2891c16e0f41ec7954d36bcb6c14c5e0de867fb;oboe-0.6.1.sha256sum=e8b61bebd49e5d43f5f8cc7ee2891c16e0f41ec7954d36bcb6c14c5e0de867fb \
    crate://crates.io/ogg/0.9.1;sha256sum=5477016638150530ba21dec7caac835b29ef69b20865751d2973fce6be386cf1;ogg-0.9.1.sha256sum=5477016638150530ba21dec7caac835b29ef69b20865751d2973fce6be386cf1 \
    crate://crates.io/once_cell/1.19.0;sha256sum=3fdb12b2476b595f9358c5161aa467c2438859caa136dec86c26fdd2efe17b92;once_cell-1.19.0.sha256sum=3fdb12b2476b595f9358c5161aa467c2438859caa136dec86c26fdd2efe17b92 \
    crate://crates.io/openssl-probe/0.1.5;sha256sum=ff011a302c396a5197692431fc1948019154afc178baf7d8e37367442a4601cf;openssl-probe-0.1.5.sha256sum=ff011a302c396a5197692431fc1948019154afc178baf7d8e37367442a4601cf \
    crate://crates.io/option-operations/0.5.0;sha256sum=7c26d27bb1aeab65138e4bf7666045169d1717febcc9ff870166be8348b223d0;option-operations-0.5.0.sha256sum=7c26d27bb1aeab65138e4bf7666045169d1717febcc9ff870166be8348b223d0 \
    crate://crates.io/parking_lot/0.12.3;sha256sum=f1bf18183cf54e8d6059647fc3063646a1801cf30896933ec2311622cc4b9a27;parking_lot-0.12.3.sha256sum=f1bf18183cf54e8d6059647fc3063646a1801cf30896933ec2311622cc4b9a27 \
    crate://crates.io/parking_lot_core/0.9.10;sha256sum=1e401f977ab385c9e4e3ab30627d6f26d00e2c73eef317493c4ec6d468726cf8;parking_lot_core-0.9.10.sha256sum=1e401f977ab385c9e4e3ab30627d6f26d00e2c73eef317493c4ec6d468726cf8 \
    crate://crates.io/paste/1.0.15;sha256sum=57c0d7b74b563b49d38dae00a0c37d4d6de9b432382b2892f0574ddcae73fd0a;paste-1.0.15.sha256sum=57c0d7b74b563b49d38dae00a0c37d4d6de9b432382b2892f0574ddcae73fd0a \
    crate://crates.io/pbkdf2/0.12.2;sha256sum=f8ed6a7761f76e3b9f92dfb0a60a6a6477c61024b775147ff0973a02653abaf2;pbkdf2-0.12.2.sha256sum=f8ed6a7761f76e3b9f92dfb0a60a6a6477c61024b775147ff0973a02653abaf2 \
    crate://crates.io/pem-rfc7468/0.7.0;sha256sum=88b39c9bfcfc231068454382784bb460aae594343fb030d46e9f50a645418412;pem-rfc7468-0.7.0.sha256sum=88b39c9bfcfc231068454382784bb460aae594343fb030d46e9f50a645418412 \
    crate://crates.io/percent-encoding/2.3.1;sha256sum=e3148f5046208a5d56bcfc03053e3ca6334e51da8dfb19b6cdc8b306fae3283e;percent-encoding-2.3.1.sha256sum=e3148f5046208a5d56bcfc03053e3ca6334e51da8dfb19b6cdc8b306fae3283e \
    crate://crates.io/petgraph/0.6.5;sha256sum=b4c5cc86750666a3ed20bdaf5ca2a0344f9c67674cae0515bec2da16fbaa47db;petgraph-0.6.5.sha256sum=b4c5cc86750666a3ed20bdaf5ca2a0344f9c67674cae0515bec2da16fbaa47db \
    crate://crates.io/pin-project-internal/1.1.5;sha256sum=2f38a4412a78282e09a2cf38d195ea5420d15ba0602cb375210efbc877243965;pin-project-internal-1.1.5.sha256sum=2f38a4412a78282e09a2cf38d195ea5420d15ba0602cb375210efbc877243965 \
    crate://crates.io/pin-project-lite/0.2.14;sha256sum=bda66fc9667c18cb2758a2ac84d1167245054bcf85d5d1aaa6923f45801bdd02;pin-project-lite-0.2.14.sha256sum=bda66fc9667c18cb2758a2ac84d1167245054bcf85d5d1aaa6923f45801bdd02 \
    crate://crates.io/pin-project/1.1.5;sha256sum=b6bf43b791c5b9e34c3d182969b4abb522f9343702850a2e57f460d00d09b4b3;pin-project-1.1.5.sha256sum=b6bf43b791c5b9e34c3d182969b4abb522f9343702850a2e57f460d00d09b4b3 \
    crate://crates.io/pin-utils/0.1.0;sha256sum=8b870d8c151b6f2fb93e84a13146138f05d02ed11c7e7c54f8826aaaf7c9f184;pin-utils-0.1.0.sha256sum=8b870d8c151b6f2fb93e84a13146138f05d02ed11c7e7c54f8826aaaf7c9f184 \
    crate://crates.io/pkcs1/0.7.5;sha256sum=c8ffb9f10fa047879315e6625af03c164b16962a5368d724ed16323b68ace47f;pkcs1-0.7.5.sha256sum=c8ffb9f10fa047879315e6625af03c164b16962a5368d724ed16323b68ace47f \
    crate://crates.io/pkcs8/0.10.2;sha256sum=f950b2377845cebe5cf8b5165cb3cc1a5e0fa5cfa3e1f7f55707d8fd82e0a7b7;pkcs8-0.10.2.sha256sum=f950b2377845cebe5cf8b5165cb3cc1a5e0fa5cfa3e1f7f55707d8fd82e0a7b7 \
    crate://crates.io/pkg-config/0.3.30;sha256sum=d231b230927b5e4ad203db57bbcbee2802f6bce620b1e4a9024a07d94e2907ec;pkg-config-0.3.30.sha256sum=d231b230927b5e4ad203db57bbcbee2802f6bce620b1e4a9024a07d94e2907ec \
    crate://crates.io/portable-atomic/1.6.0;sha256sum=7170ef9988bc169ba16dd36a7fa041e5c4cbeb6a35b76d4c03daded371eae7c0;portable-atomic-1.6.0.sha256sum=7170ef9988bc169ba16dd36a7fa041e5c4cbeb6a35b76d4c03daded371eae7c0 \
    crate://crates.io/portaudio-rs/0.3.2;sha256sum=cdb6b5eff96ccc9bf44d34c379ab03ae944426d83d1694345bdf8159d561d562;portaudio-rs-0.3.2.sha256sum=cdb6b5eff96ccc9bf44d34c379ab03ae944426d83d1694345bdf8159d561d562 \
    crate://crates.io/portaudio-sys/0.1.1;sha256sum=5194a4fa953b4ffd851c320ef6f0484cd7278cb7169ea9d6c433e49b23f7b7f5;portaudio-sys-0.1.1.sha256sum=5194a4fa953b4ffd851c320ef6f0484cd7278cb7169ea9d6c433e49b23f7b7f5 \
    crate://crates.io/powerfmt/0.2.0;sha256sum=439ee305def115ba05938db6eb1644ff94165c5ab5e9420d1c1bcedbba909391;powerfmt-0.2.0.sha256sum=439ee305def115ba05938db6eb1644ff94165c5ab5e9420d1c1bcedbba909391 \
    crate://crates.io/ppv-lite86/0.2.17;sha256sum=5b40af805b3121feab8a3c29f04d8ad262fa8e0561883e7653e024ae4479e6de;ppv-lite86-0.2.17.sha256sum=5b40af805b3121feab8a3c29f04d8ad262fa8e0561883e7653e024ae4479e6de \
    crate://crates.io/priority-queue/2.0.3;sha256sum=70c501afe3a2e25c9bd219aa56ec1e04cdb3fcdd763055be268778c13fa82c1f;priority-queue-2.0.3.sha256sum=70c501afe3a2e25c9bd219aa56ec1e04cdb3fcdd763055be268778c13fa82c1f \
    crate://crates.io/proc-macro-crate/3.1.0;sha256sum=6d37c51ca738a55da99dc0c4a34860fd675453b8b36209178c2249bb13651284;proc-macro-crate-3.1.0.sha256sum=6d37c51ca738a55da99dc0c4a34860fd675453b8b36209178c2249bb13651284 \
    crate://crates.io/proc-macro2/1.0.85;sha256sum=22244ce15aa966053a896d1accb3a6e68469b97c7f33f284b99f0d576879fc23;proc-macro2-1.0.85.sha256sum=22244ce15aa966053a896d1accb3a6e68469b97c7f33f284b99f0d576879fc23 \
    crate://crates.io/protobuf-codegen/3.4.0;sha256sum=32777b0b3f6538d9d2e012b3fad85c7e4b9244b5958d04a6415f4333782b7a77;protobuf-codegen-3.4.0.sha256sum=32777b0b3f6538d9d2e012b3fad85c7e4b9244b5958d04a6415f4333782b7a77 \
    crate://crates.io/protobuf-parse/3.4.0;sha256sum=96cb37955261126624a25b5e6bda40ae34cf3989d52a783087ca6091b29b5642;protobuf-parse-3.4.0.sha256sum=96cb37955261126624a25b5e6bda40ae34cf3989d52a783087ca6091b29b5642 \
    crate://crates.io/protobuf-support/3.4.0;sha256sum=e1ed294a835b0f30810e13616b1cd34943c6d1e84a8f3b0dcfe466d256c3e7e7;protobuf-support-3.4.0.sha256sum=e1ed294a835b0f30810e13616b1cd34943c6d1e84a8f3b0dcfe466d256c3e7e7 \
    crate://crates.io/protobuf/3.4.0;sha256sum=58678a64de2fced2bdec6bca052a6716a0efe692d6e3f53d1bda6a1def64cfc0;protobuf-3.4.0.sha256sum=58678a64de2fced2bdec6bca052a6716a0efe692d6e3f53d1bda6a1def64cfc0 \
    crate://crates.io/quick-xml/0.32.0;sha256sum=1d3a6e5838b60e0e8fa7a43f22ade549a37d61f8bdbe636d0d7816191de969c2;quick-xml-0.32.0.sha256sum=1d3a6e5838b60e0e8fa7a43f22ade549a37d61f8bdbe636d0d7816191de969c2 \
    crate://crates.io/quote/1.0.36;sha256sum=0fa76aaf39101c457836aec0ce2316dbdc3ab723cdda1c6bd4e6ad4208acaca7;quote-1.0.36.sha256sum=0fa76aaf39101c457836aec0ce2316dbdc3ab723cdda1c6bd4e6ad4208acaca7 \
    crate://crates.io/rand/0.8.5;sha256sum=34af8d1a0e25924bc5b7c43c079c942339d8f0a8b57c39049bef581b46327404;rand-0.8.5.sha256sum=34af8d1a0e25924bc5b7c43c079c942339d8f0a8b57c39049bef581b46327404 \
    crate://crates.io/rand_chacha/0.3.1;sha256sum=e6c10a63a0fa32252be49d21e7709d4d4baf8d231c2dbce1eaa8141b9b127d88;rand_chacha-0.3.1.sha256sum=e6c10a63a0fa32252be49d21e7709d4d4baf8d231c2dbce1eaa8141b9b127d88 \
    crate://crates.io/rand_core/0.6.4;sha256sum=ec0be4795e2f6a28069bec0b5ff3e2ac9bafc99e6a9a7dc3547996c5c816922c;rand_core-0.6.4.sha256sum=ec0be4795e2f6a28069bec0b5ff3e2ac9bafc99e6a9a7dc3547996c5c816922c \
    crate://crates.io/rand_distr/0.4.3;sha256sum=32cb0b9bc82b0a0876c2dd994a7e7a2683d3e7390ca40e6886785ef0c7e3ee31;rand_distr-0.4.3.sha256sum=32cb0b9bc82b0a0876c2dd994a7e7a2683d3e7390ca40e6886785ef0c7e3ee31 \
    crate://crates.io/redox_syscall/0.5.1;sha256sum=469052894dcb553421e483e4209ee581a45100d31b4018de03e5a7ad86374a7e;redox_syscall-0.5.1.sha256sum=469052894dcb553421e483e4209ee581a45100d31b4018de03e5a7ad86374a7e \
    crate://crates.io/regex-automata/0.4.7;sha256sum=38caf58cc5ef2fed281f89292ef23f6365465ed9a41b7a7754eb4e26496c92df;regex-automata-0.4.7.sha256sum=38caf58cc5ef2fed281f89292ef23f6365465ed9a41b7a7754eb4e26496c92df \
    crate://crates.io/regex-syntax/0.8.4;sha256sum=7a66a03ae7c801facd77a29370b4faec201768915ac14a721ba36f20bc9c209b;regex-syntax-0.8.4.sha256sum=7a66a03ae7c801facd77a29370b4faec201768915ac14a721ba36f20bc9c209b \
    crate://crates.io/regex/1.10.5;sha256sum=b91213439dad192326a0d7c6ee3955910425f441d7038e0d6933b0aec5c4517f;regex-1.10.5.sha256sum=b91213439dad192326a0d7c6ee3955910425f441d7038e0d6933b0aec5c4517f \
    crate://crates.io/ring/0.17.8;sha256sum=c17fa4cb658e3583423e915b9f3acc01cceaee1860e33d59ebae66adc3a2dc0d;ring-0.17.8.sha256sum=c17fa4cb658e3583423e915b9f3acc01cceaee1860e33d59ebae66adc3a2dc0d \
    crate://crates.io/rodio/0.18.1;sha256sum=d1fceb9d127d515af1586d8d0cc601e1245bdb0af38e75c865a156290184f5b3;rodio-0.18.1.sha256sum=d1fceb9d127d515af1586d8d0cc601e1245bdb0af38e75c865a156290184f5b3 \
    crate://crates.io/rpassword/7.3.1;sha256sum=80472be3c897911d0137b2d2b9055faf6eeac5b14e324073d83bc17b191d7e3f;rpassword-7.3.1.sha256sum=80472be3c897911d0137b2d2b9055faf6eeac5b14e324073d83bc17b191d7e3f \
    crate://crates.io/rsa/0.9.6;sha256sum=5d0e5124fcb30e76a7e79bfee683a2746db83784b86289f6251b54b7950a0dfc;rsa-0.9.6.sha256sum=5d0e5124fcb30e76a7e79bfee683a2746db83784b86289f6251b54b7950a0dfc \
    crate://crates.io/rtoolbox/0.0.2;sha256sum=c247d24e63230cdb56463ae328478bd5eac8b8faa8c69461a77e8e323afac90e;rtoolbox-0.0.2.sha256sum=c247d24e63230cdb56463ae328478bd5eac8b8faa8c69461a77e8e323afac90e \
    crate://crates.io/rustc-demangle/0.1.24;sha256sum=719b953e2095829ee67db738b3bfa9fa368c94900df327b3f07fe6e794d2fe1f;rustc-demangle-0.1.24.sha256sum=719b953e2095829ee67db738b3bfa9fa368c94900df327b3f07fe6e794d2fe1f \
    crate://crates.io/rustc-hash/1.1.0;sha256sum=08d43f7aa6b08d49f382cde6a7982047c3426db949b1424bc4b7ec9ae12c6ce2;rustc-hash-1.1.0.sha256sum=08d43f7aa6b08d49f382cde6a7982047c3426db949b1424bc4b7ec9ae12c6ce2 \
    crate://crates.io/rustix/0.38.34;sha256sum=70dc5ec042f7a43c4a73241207cecc9873a06d45debb38b329f8541d85c2730f;rustix-0.38.34.sha256sum=70dc5ec042f7a43c4a73241207cecc9873a06d45debb38b329f8541d85c2730f \
    crate://crates.io/rustls-native-certs/0.7.0;sha256sum=8f1fb85efa936c42c6d5fc28d2629bb51e4b2f4b8a5211e297d599cc5a093792;rustls-native-certs-0.7.0.sha256sum=8f1fb85efa936c42c6d5fc28d2629bb51e4b2f4b8a5211e297d599cc5a093792 \
    crate://crates.io/rustls-pemfile/2.1.2;sha256sum=29993a25686778eb88d4189742cd713c9bce943bc54251a33509dc63cbacf73d;rustls-pemfile-2.1.2.sha256sum=29993a25686778eb88d4189742cd713c9bce943bc54251a33509dc63cbacf73d \
    crate://crates.io/rustls-pki-types/1.7.0;sha256sum=976295e77ce332211c0d24d92c0e83e50f5c5f046d11082cea19f3df13a3562d;rustls-pki-types-1.7.0.sha256sum=976295e77ce332211c0d24d92c0e83e50f5c5f046d11082cea19f3df13a3562d \
    crate://crates.io/rustls-webpki/0.102.4;sha256sum=ff448f7e92e913c4b7d4c6d8e4540a1724b319b4152b8aef6d4cf8339712b33e;rustls-webpki-0.102.4.sha256sum=ff448f7e92e913c4b7d4c6d8e4540a1724b319b4152b8aef6d4cf8339712b33e \
    crate://crates.io/rustls/0.22.4;sha256sum=bf4ef73721ac7bcd79b2b315da7779d8fc09718c6b3d2d1b2d94850eb8c18432;rustls-0.22.4.sha256sum=bf4ef73721ac7bcd79b2b315da7779d8fc09718c6b3d2d1b2d94850eb8c18432 \
    crate://crates.io/rustls/0.23.9;sha256sum=a218f0f6d05669de4eabfb24f31ce802035c952429d037507b4a4a39f0e60c5b;rustls-0.23.9.sha256sum=a218f0f6d05669de4eabfb24f31ce802035c952429d037507b4a4a39f0e60c5b \
    crate://crates.io/rustversion/1.0.17;sha256sum=955d28af4278de8121b7ebeb796b6a45735dc01436d898801014aced2773a3d6;rustversion-1.0.17.sha256sum=955d28af4278de8121b7ebeb796b6a45735dc01436d898801014aced2773a3d6 \
    crate://crates.io/ryu/1.0.18;sha256sum=f3cb5ba0dc43242ce17de99c180e96db90b235b8a9fdc9543c96d2209116bd9f;ryu-1.0.18.sha256sum=f3cb5ba0dc43242ce17de99c180e96db90b235b8a9fdc9543c96d2209116bd9f \
    crate://crates.io/same-file/1.0.6;sha256sum=93fc1dc3aaa9bfed95e02e6eadabb4baf7e3078b0bd1b4d7b6b0b68378900502;same-file-1.0.6.sha256sum=93fc1dc3aaa9bfed95e02e6eadabb4baf7e3078b0bd1b4d7b6b0b68378900502 \
    crate://crates.io/schannel/0.1.23;sha256sum=fbc91545643bcf3a0bbb6569265615222618bdf33ce4ffbbd13c4bbd4c093534;schannel-0.1.23.sha256sum=fbc91545643bcf3a0bbb6569265615222618bdf33ce4ffbbd13c4bbd4c093534 \
    crate://crates.io/scopeguard/1.2.0;sha256sum=94143f37725109f92c262ed2cf5e59bce7498c01bcc1502d7b9afe439a4e9f49;scopeguard-1.2.0.sha256sum=94143f37725109f92c262ed2cf5e59bce7498c01bcc1502d7b9afe439a4e9f49 \
    crate://crates.io/sdl2-sys/0.36.0;sha256sum=26bcacfdd45d539fb5785049feb0038a63931aa896c7763a2a12e125ec58bd29;sdl2-sys-0.36.0.sha256sum=26bcacfdd45d539fb5785049feb0038a63931aa896c7763a2a12e125ec58bd29 \
    crate://crates.io/sdl2/0.36.0;sha256sum=8356b2697d1ead5a34f40bcc3c5d3620205fe0c7be0a14656223bfeec0258891;sdl2-0.36.0.sha256sum=8356b2697d1ead5a34f40bcc3c5d3620205fe0c7be0a14656223bfeec0258891 \
    crate://crates.io/security-framework-sys/2.11.0;sha256sum=317936bbbd05227752583946b9e66d7ce3b489f84e11a94a510b4437fef407d7;security-framework-sys-2.11.0.sha256sum=317936bbbd05227752583946b9e66d7ce3b489f84e11a94a510b4437fef407d7 \
    crate://crates.io/security-framework/2.11.0;sha256sum=c627723fd09706bacdb5cf41499e95098555af3c3c29d014dc3c458ef6be11c0;security-framework-2.11.0.sha256sum=c627723fd09706bacdb5cf41499e95098555af3c3c29d014dc3c458ef6be11c0 \
    crate://crates.io/serde/1.0.203;sha256sum=7253ab4de971e72fb7be983802300c30b5a7f0c2e56fab8abfc6a214307c0094;serde-1.0.203.sha256sum=7253ab4de971e72fb7be983802300c30b5a7f0c2e56fab8abfc6a214307c0094 \
    crate://crates.io/serde_derive/1.0.203;sha256sum=500cbc0ebeb6f46627f50f3f5811ccf6bf00643be300b4c3eabc0ef55dc5b5ba;serde_derive-1.0.203.sha256sum=500cbc0ebeb6f46627f50f3f5811ccf6bf00643be300b4c3eabc0ef55dc5b5ba \
    crate://crates.io/serde_json/1.0.117;sha256sum=455182ea6142b14f93f4bc5320a2b31c1f266b66a4a5c858b013302a5d8cbfc3;serde_json-1.0.117.sha256sum=455182ea6142b14f93f4bc5320a2b31c1f266b66a4a5c858b013302a5d8cbfc3 \
    crate://crates.io/serde_spanned/0.6.6;sha256sum=79e674e01f999af37c49f70a6ede167a8a60b2503e56c5599532a65baa5969a0;serde_spanned-0.6.6.sha256sum=79e674e01f999af37c49f70a6ede167a8a60b2503e56c5599532a65baa5969a0 \
    crate://crates.io/sha1/0.10.6;sha256sum=e3bf829a2d51ab4a5ddf1352d8470c140cadc8301b2ae1789db023f01cedd6ba;sha1-0.10.6.sha256sum=e3bf829a2d51ab4a5ddf1352d8470c140cadc8301b2ae1789db023f01cedd6ba \
    crate://crates.io/shannon/0.2.0;sha256sum=7ea5b41c9427b56caa7b808cb548a04fb50bb5b9e98590b53f28064ff4174561;shannon-0.2.0.sha256sum=7ea5b41c9427b56caa7b808cb548a04fb50bb5b9e98590b53f28064ff4174561 \
    crate://crates.io/shell-words/1.1.0;sha256sum=24188a676b6ae68c3b2cb3a01be17fbf7240ce009799bb56d5b1409051e78fde;shell-words-1.1.0.sha256sum=24188a676b6ae68c3b2cb3a01be17fbf7240ce009799bb56d5b1409051e78fde \
    crate://crates.io/shlex/1.3.0;sha256sum=0fda2ff0d084019ba4d7c6f371c95d8fd75ce3524c3cb8fb653a3023f6323e64;shlex-1.3.0.sha256sum=0fda2ff0d084019ba4d7c6f371c95d8fd75ce3524c3cb8fb653a3023f6323e64 \
    crate://crates.io/signal-hook-registry/1.4.2;sha256sum=a9e9e0b4211b72e7b8b6e85c807d36c212bdb33ea8587f7569562a84df5465b1;signal-hook-registry-1.4.2.sha256sum=a9e9e0b4211b72e7b8b6e85c807d36c212bdb33ea8587f7569562a84df5465b1 \
    crate://crates.io/signature/2.2.0;sha256sum=77549399552de45a898a580c1b41d445bf730df867cc44e6c0233bbc4b8329de;signature-2.2.0.sha256sum=77549399552de45a898a580c1b41d445bf730df867cc44e6c0233bbc4b8329de \
    crate://crates.io/slab/0.4.9;sha256sum=8f92a496fb766b417c996b9c5e57daf2f7ad3b0bebe1ccfca4856390e3d3bb67;slab-0.4.9.sha256sum=8f92a496fb766b417c996b9c5e57daf2f7ad3b0bebe1ccfca4856390e3d3bb67 \
    crate://crates.io/smallvec/1.13.2;sha256sum=3c5e1a9a646d36c3599cd173a41282daf47c44583ad367b8e6837255952e5c67;smallvec-1.13.2.sha256sum=3c5e1a9a646d36c3599cd173a41282daf47c44583ad367b8e6837255952e5c67 \
    crate://crates.io/socket2/0.5.7;sha256sum=ce305eb0b4296696835b71df73eb912e0f1ffd2556a501fcede6e0c50349191c;socket2-0.5.7.sha256sum=ce305eb0b4296696835b71df73eb912e0f1ffd2556a501fcede6e0c50349191c \
    crate://crates.io/spin/0.5.2;sha256sum=6e63cff320ae2c57904679ba7cb63280a3dc4613885beafb148ee7bf9aa9042d;spin-0.5.2.sha256sum=6e63cff320ae2c57904679ba7cb63280a3dc4613885beafb148ee7bf9aa9042d \
    crate://crates.io/spin/0.9.8;sha256sum=6980e8d7511241f8acf4aebddbb1ff938df5eebe98691418c4468d0b72a96a67;spin-0.9.8.sha256sum=6980e8d7511241f8acf4aebddbb1ff938df5eebe98691418c4468d0b72a96a67 \
    crate://crates.io/spinning_top/0.3.0;sha256sum=d96d2d1d716fb500937168cc09353ffdc7a012be8475ac7308e1bdf0e3923300;spinning_top-0.3.0.sha256sum=d96d2d1d716fb500937168cc09353ffdc7a012be8475ac7308e1bdf0e3923300 \
    crate://crates.io/spki/0.7.3;sha256sum=d91ed6c858b01f942cd56b37a94b3e0a1798290327d1236e4d9cf4eaca44d29d;spki-0.7.3.sha256sum=d91ed6c858b01f942cd56b37a94b3e0a1798290327d1236e4d9cf4eaca44d29d \
    crate://crates.io/stable_deref_trait/1.2.0;sha256sum=a8f112729512f8e442d81f95a8a7ddf2b7c6b8a1a6f509a95864142b30cab2d3;stable_deref_trait-1.2.0.sha256sum=a8f112729512f8e442d81f95a8a7ddf2b7c6b8a1a6f509a95864142b30cab2d3 \
    crate://crates.io/subtle/2.5.0;sha256sum=81cdd64d312baedb58e21336b31bc043b77e01cc99033ce76ef539f78e965ebc;subtle-2.5.0.sha256sum=81cdd64d312baedb58e21336b31bc043b77e01cc99033ce76ef539f78e965ebc \
    crate://crates.io/symphonia-bundle-mp3/0.5.4;sha256sum=c01c2aae70f0f1fb096b6f0ff112a930b1fb3626178fba3ae68b09dce71706d4;symphonia-bundle-mp3-0.5.4.sha256sum=c01c2aae70f0f1fb096b6f0ff112a930b1fb3626178fba3ae68b09dce71706d4 \
    crate://crates.io/symphonia-codec-vorbis/0.5.4;sha256sum=5a98765fb46a0a6732b007f7e2870c2129b6f78d87db7987e6533c8f164a9f30;symphonia-codec-vorbis-0.5.4.sha256sum=5a98765fb46a0a6732b007f7e2870c2129b6f78d87db7987e6533c8f164a9f30 \
    crate://crates.io/symphonia-core/0.5.4;sha256sum=798306779e3dc7d5231bd5691f5a813496dc79d3f56bf82e25789f2094e022c3;symphonia-core-0.5.4.sha256sum=798306779e3dc7d5231bd5691f5a813496dc79d3f56bf82e25789f2094e022c3 \
    crate://crates.io/symphonia-format-ogg/0.5.4;sha256sum=ada3505789516bcf00fc1157c67729eded428b455c27ca370e41f4d785bfa931;symphonia-format-ogg-0.5.4.sha256sum=ada3505789516bcf00fc1157c67729eded428b455c27ca370e41f4d785bfa931 \
    crate://crates.io/symphonia-metadata/0.5.4;sha256sum=bc622b9841a10089c5b18e99eb904f4341615d5aa55bbf4eedde1be721a4023c;symphonia-metadata-0.5.4.sha256sum=bc622b9841a10089c5b18e99eb904f4341615d5aa55bbf4eedde1be721a4023c \
    crate://crates.io/symphonia-utils-xiph/0.5.4;sha256sum=484472580fa49991afda5f6550ece662237b00c6f562c7d9638d1b086ed010fe;symphonia-utils-xiph-0.5.4.sha256sum=484472580fa49991afda5f6550ece662237b00c6f562c7d9638d1b086ed010fe \
    crate://crates.io/symphonia/0.5.4;sha256sum=815c942ae7ee74737bb00f965fa5b5a2ac2ce7b6c01c0cc169bbeaf7abd5f5a9;symphonia-0.5.4.sha256sum=815c942ae7ee74737bb00f965fa5b5a2ac2ce7b6c01c0cc169bbeaf7abd5f5a9 \
    crate://crates.io/syn/1.0.109;sha256sum=72b64191b275b66ffe2469e8af2c1cfe3bafa67b529ead792a6d0160888b4237;syn-1.0.109.sha256sum=72b64191b275b66ffe2469e8af2c1cfe3bafa67b529ead792a6d0160888b4237 \
    crate://crates.io/syn/2.0.66;sha256sum=c42f3f41a2de00b01c0aaad383c5a45241efc8b2d1eda5661812fda5f3cdcff5;syn-2.0.66.sha256sum=c42f3f41a2de00b01c0aaad383c5a45241efc8b2d1eda5661812fda5f3cdcff5 \
    crate://crates.io/synstructure/0.13.1;sha256sum=c8af7666ab7b6390ab78131fb5b0fce11d6b7a6951602017c35fa82800708971;synstructure-0.13.1.sha256sum=c8af7666ab7b6390ab78131fb5b0fce11d6b7a6951602017c35fa82800708971 \
    crate://crates.io/sysinfo/0.30.12;sha256sum=732ffa00f53e6b2af46208fba5718d9662a421049204e156328b66791ffa15ae;sysinfo-0.30.12.sha256sum=732ffa00f53e6b2af46208fba5718d9662a421049204e156328b66791ffa15ae \
    crate://crates.io/system-deps/6.2.2;sha256sum=a3e535eb8dded36d55ec13eddacd30dec501792ff23a0b1682c38601b8cf2349;system-deps-6.2.2.sha256sum=a3e535eb8dded36d55ec13eddacd30dec501792ff23a0b1682c38601b8cf2349 \
    crate://crates.io/target-lexicon/0.12.14;sha256sum=e1fc403891a21bcfb7c37834ba66a547a8f402146eba7265b5a6d88059c9ff2f;target-lexicon-0.12.14.sha256sum=e1fc403891a21bcfb7c37834ba66a547a8f402146eba7265b5a6d88059c9ff2f \
    crate://crates.io/tempfile/3.10.1;sha256sum=85b77fafb263dd9d05cbeac119526425676db3784113aa9295c88498cbf8bff1;tempfile-3.10.1.sha256sum=85b77fafb263dd9d05cbeac119526425676db3784113aa9295c88498cbf8bff1 \
    crate://crates.io/thiserror-impl/1.0.61;sha256sum=46c3384250002a6d5af4d114f2845d37b57521033f30d5c3f46c4d70e1197533;thiserror-impl-1.0.61.sha256sum=46c3384250002a6d5af4d114f2845d37b57521033f30d5c3f46c4d70e1197533 \
    crate://crates.io/thiserror/1.0.61;sha256sum=c546c80d6be4bc6a00c0f01730c08df82eaa7a7a61f11d656526506112cc1709;thiserror-1.0.61.sha256sum=c546c80d6be4bc6a00c0f01730c08df82eaa7a7a61f11d656526506112cc1709 \
    crate://crates.io/thread-id/4.2.1;sha256sum=f0ec81c46e9eb50deaa257be2f148adf052d1fb7701cfd55ccfab2525280b70b;thread-id-4.2.1.sha256sum=f0ec81c46e9eb50deaa257be2f148adf052d1fb7701cfd55ccfab2525280b70b \
    crate://crates.io/time-core/0.1.2;sha256sum=ef927ca75afb808a4d64dd374f00a2adf8d0fcff8e7b184af886c3c87ec4a3f3;time-core-0.1.2.sha256sum=ef927ca75afb808a4d64dd374f00a2adf8d0fcff8e7b184af886c3c87ec4a3f3 \
    crate://crates.io/time-macros/0.2.18;sha256sum=3f252a68540fde3a3877aeea552b832b40ab9a69e318efd078774a01ddee1ccf;time-macros-0.2.18.sha256sum=3f252a68540fde3a3877aeea552b832b40ab9a69e318efd078774a01ddee1ccf \
    crate://crates.io/time/0.3.36;sha256sum=5dfd88e563464686c916c7e46e623e520ddc6d79fa6641390f2e3fa86e83e885;time-0.3.36.sha256sum=5dfd88e563464686c916c7e46e623e520ddc6d79fa6641390f2e3fa86e83e885 \
    crate://crates.io/tinystr/0.7.6;sha256sum=9117f5d4db391c1cf6927e7bea3db74b9a1c1add8f7eda9ffd5364f40f57b82f;tinystr-0.7.6.sha256sum=9117f5d4db391c1cf6927e7bea3db74b9a1c1add8f7eda9ffd5364f40f57b82f \
    crate://crates.io/tokio-macros/2.3.0;sha256sum=5f5ae998a069d4b5aba8ee9dad856af7d520c3699e6159b185c2acd48155d39a;tokio-macros-2.3.0.sha256sum=5f5ae998a069d4b5aba8ee9dad856af7d520c3699e6159b185c2acd48155d39a \
    crate://crates.io/tokio-rustls/0.25.0;sha256sum=775e0c0f0adb3a2f22a00c4745d728b479985fc15ee7ca6a2608388c5569860f;tokio-rustls-0.25.0.sha256sum=775e0c0f0adb3a2f22a00c4745d728b479985fc15ee7ca6a2608388c5569860f \
    crate://crates.io/tokio-rustls/0.26.0;sha256sum=0c7bc40d0e5a97695bb96e27995cd3a08538541b0a846f65bba7a359f36700d4;tokio-rustls-0.26.0.sha256sum=0c7bc40d0e5a97695bb96e27995cd3a08538541b0a846f65bba7a359f36700d4 \
    crate://crates.io/tokio-stream/0.1.15;sha256sum=267ac89e0bec6e691e5813911606935d77c476ff49024f98abcea3e7b15e37af;tokio-stream-0.1.15.sha256sum=267ac89e0bec6e691e5813911606935d77c476ff49024f98abcea3e7b15e37af \
    crate://crates.io/tokio-tungstenite/0.23.0;sha256sum=becd34a233e7e31a3dbf7c7241b38320f57393dcae8e7324b0167d21b8e320b0;tokio-tungstenite-0.23.0.sha256sum=becd34a233e7e31a3dbf7c7241b38320f57393dcae8e7324b0167d21b8e320b0 \
    crate://crates.io/tokio-util/0.7.11;sha256sum=9cf6b47b3771c49ac75ad09a6162f53ad4b8088b76ac60e8ec1455b31a189fe1;tokio-util-0.7.11.sha256sum=9cf6b47b3771c49ac75ad09a6162f53ad4b8088b76ac60e8ec1455b31a189fe1 \
    crate://crates.io/tokio/1.38.0;sha256sum=ba4f4a02a7a80d6f274636f0aa95c7e383b912d41fe721a31f29e29698585a4a;tokio-1.38.0.sha256sum=ba4f4a02a7a80d6f274636f0aa95c7e383b912d41fe721a31f29e29698585a4a \
    crate://crates.io/toml/0.8.14;sha256sum=6f49eb2ab21d2f26bd6db7bf383edc527a7ebaee412d17af4d40fdccd442f335;toml-0.8.14.sha256sum=6f49eb2ab21d2f26bd6db7bf383edc527a7ebaee412d17af4d40fdccd442f335 \
    crate://crates.io/toml_datetime/0.6.6;sha256sum=4badfd56924ae69bcc9039335b2e017639ce3f9b001c393c1b2d1ef846ce2cbf;toml_datetime-0.6.6.sha256sum=4badfd56924ae69bcc9039335b2e017639ce3f9b001c393c1b2d1ef846ce2cbf \
    crate://crates.io/toml_edit/0.21.1;sha256sum=6a8534fd7f78b5405e860340ad6575217ce99f38d4d5c8f2442cb5ecb50090e1;toml_edit-0.21.1.sha256sum=6a8534fd7f78b5405e860340ad6575217ce99f38d4d5c8f2442cb5ecb50090e1 \
    crate://crates.io/toml_edit/0.22.14;sha256sum=f21c7aaf97f1bd9ca9d4f9e73b0a6c74bd5afef56f2bc931943a6e1c37e04e38;toml_edit-0.22.14.sha256sum=f21c7aaf97f1bd9ca9d4f9e73b0a6c74bd5afef56f2bc931943a6e1c37e04e38 \
    crate://crates.io/tower-layer/0.3.2;sha256sum=c20c8dbed6283a09604c3e69b4b7eeb54e298b8a600d4d5ecb5ad39de609f1d0;tower-layer-0.3.2.sha256sum=c20c8dbed6283a09604c3e69b4b7eeb54e298b8a600d4d5ecb5ad39de609f1d0 \
    crate://crates.io/tower-service/0.3.2;sha256sum=b6bc1c9ce2b5135ac7f93c72918fc37feb872bdc6a5533a8b85eb4b86bfdae52;tower-service-0.3.2.sha256sum=b6bc1c9ce2b5135ac7f93c72918fc37feb872bdc6a5533a8b85eb4b86bfdae52 \
    crate://crates.io/tower/0.4.13;sha256sum=b8fa9be0de6cf49e536ce1851f987bd21a43b771b09473c3549a6c853db37c1c;tower-0.4.13.sha256sum=b8fa9be0de6cf49e536ce1851f987bd21a43b771b09473c3549a6c853db37c1c \
    crate://crates.io/tracing-core/0.1.32;sha256sum=c06d3da6113f116aaee68e4d601191614c9053067f9ab7f6edbcb161237daa54;tracing-core-0.1.32.sha256sum=c06d3da6113f116aaee68e4d601191614c9053067f9ab7f6edbcb161237daa54 \
    crate://crates.io/tracing/0.1.40;sha256sum=c3523ab5a71916ccf420eebdf5521fcef02141234bbc0b8a49f2fdc4544364ef;tracing-0.1.40.sha256sum=c3523ab5a71916ccf420eebdf5521fcef02141234bbc0b8a49f2fdc4544364ef \
    crate://crates.io/try-lock/0.2.5;sha256sum=e421abadd41a4225275504ea4d6566923418b7f05506fbc9c0fe86ba7396114b;try-lock-0.2.5.sha256sum=e421abadd41a4225275504ea4d6566923418b7f05506fbc9c0fe86ba7396114b \
    crate://crates.io/tungstenite/0.23.0;sha256sum=6e2e2ce1e47ed2994fd43b04c8f618008d4cabdd5ee34027cf14f9d918edd9c8;tungstenite-0.23.0.sha256sum=6e2e2ce1e47ed2994fd43b04c8f618008d4cabdd5ee34027cf14f9d918edd9c8 \
    crate://crates.io/typenum/1.17.0;sha256sum=42ff0bf0c66b8238c6f3b578df37d0b7848e55df8577b3f74f92a69acceeb825;typenum-1.17.0.sha256sum=42ff0bf0c66b8238c6f3b578df37d0b7848e55df8577b3f74f92a69acceeb825 \
    crate://crates.io/unicode-ident/1.0.12;sha256sum=3354b9ac3fae1ff6755cb6db53683adb661634f67557942dea4facebec0fee4b;unicode-ident-1.0.12.sha256sum=3354b9ac3fae1ff6755cb6db53683adb661634f67557942dea4facebec0fee4b \
    crate://crates.io/unicode-width/0.1.13;sha256sum=0336d538f7abc86d282a4189614dfaa90810dfc2c6f6427eaf88e16311dd225d;unicode-width-0.1.13.sha256sum=0336d538f7abc86d282a4189614dfaa90810dfc2c6f6427eaf88e16311dd225d \
    crate://crates.io/untrusted/0.9.0;sha256sum=8ecb6da28b8a351d773b68d5825ac39017e680750f980f3a1a85cd8dd28a47c1;untrusted-0.9.0.sha256sum=8ecb6da28b8a351d773b68d5825ac39017e680750f980f3a1a85cd8dd28a47c1 \
    crate://crates.io/url/2.5.1;sha256sum=f7c25da092f0a868cdf09e8674cd3b7ef3a7d92a24253e663a2fb85e2496de56;url-2.5.1.sha256sum=f7c25da092f0a868cdf09e8674cd3b7ef3a7d92a24253e663a2fb85e2496de56 \
    crate://crates.io/utf-8/0.7.6;sha256sum=09cc8ee72d2a9becf2f2febe0205bbed8fc6615b7cb429ad062dc7b7ddd036a9;utf-8-0.7.6.sha256sum=09cc8ee72d2a9becf2f2febe0205bbed8fc6615b7cb429ad062dc7b7ddd036a9 \
    crate://crates.io/utf16_iter/1.0.5;sha256sum=c8232dd3cdaed5356e0f716d285e4b40b932ac434100fe9b7e0e8e935b9e6246;utf16_iter-1.0.5.sha256sum=c8232dd3cdaed5356e0f716d285e4b40b932ac434100fe9b7e0e8e935b9e6246 \
    crate://crates.io/utf8_iter/1.0.4;sha256sum=b6c140620e7ffbb22c2dee59cafe6084a59b5ffc27a8859a5f0d494b5d52b6be;utf8_iter-1.0.4.sha256sum=b6c140620e7ffbb22c2dee59cafe6084a59b5ffc27a8859a5f0d494b5d52b6be \
    crate://crates.io/utf8parse/0.2.2;sha256sum=06abde3611657adf66d383f00b093d7faecc7fa57071cce2578660c9f1010821;utf8parse-0.2.2.sha256sum=06abde3611657adf66d383f00b093d7faecc7fa57071cce2578660c9f1010821 \
    crate://crates.io/uuid/1.8.0;sha256sum=a183cf7feeba97b4dd1c0d46788634f6221d87fa961b305bed08c851829efcc0;uuid-1.8.0.sha256sum=a183cf7feeba97b4dd1c0d46788634f6221d87fa961b305bed08c851829efcc0 \
    crate://crates.io/vergen/8.3.1;sha256sum=e27d6bdd219887a9eadd19e1c34f32e47fa332301184935c6d9bca26f3cca525;vergen-8.3.1.sha256sum=e27d6bdd219887a9eadd19e1c34f32e47fa332301184935c6d9bca26f3cca525 \
    crate://crates.io/version-compare/0.1.1;sha256sum=579a42fc0b8e0c63b76519a339be31bed574929511fa53c1a3acae26eb258f29;version-compare-0.1.1.sha256sum=579a42fc0b8e0c63b76519a339be31bed574929511fa53c1a3acae26eb258f29 \
    crate://crates.io/version-compare/0.2.0;sha256sum=852e951cb7832cb45cb1169900d19760cfa39b82bc0ea9c0e5a14ae88411c98b;version-compare-0.2.0.sha256sum=852e951cb7832cb45cb1169900d19760cfa39b82bc0ea9c0e5a14ae88411c98b \
    crate://crates.io/version_check/0.9.4;sha256sum=49874b5167b65d7193b8aba1567f5c7d93d001cafc34600cee003eda787e483f;version_check-0.9.4.sha256sum=49874b5167b65d7193b8aba1567f5c7d93d001cafc34600cee003eda787e483f \
    crate://crates.io/walkdir/2.5.0;sha256sum=29790946404f91d9c5d06f9874efddea1dc06c5efe94541a7d6863108e3a5e4b;walkdir-2.5.0.sha256sum=29790946404f91d9c5d06f9874efddea1dc06c5efe94541a7d6863108e3a5e4b \
    crate://crates.io/want/0.3.1;sha256sum=bfa7760aed19e106de2c7c0b581b509f2f25d3dacaf737cb82ac61bc6d760b0e;want-0.3.1.sha256sum=bfa7760aed19e106de2c7c0b581b509f2f25d3dacaf737cb82ac61bc6d760b0e \
    crate://crates.io/wasi/0.11.0+wasi-snapshot-preview1;sha256sum=9c8d87e72b64a3b4db28d11ce29237c246188f4f51057d65a7eab63b7987e423;wasi-0.11.0+wasi-snapshot-preview1.sha256sum=9c8d87e72b64a3b4db28d11ce29237c246188f4f51057d65a7eab63b7987e423 \
    crate://crates.io/wasm-bindgen-backend/0.2.92;sha256sum=614d787b966d3989fa7bb98a654e369c762374fd3213d212cfc0251257e747da;wasm-bindgen-backend-0.2.92.sha256sum=614d787b966d3989fa7bb98a654e369c762374fd3213d212cfc0251257e747da \
    crate://crates.io/wasm-bindgen-futures/0.4.42;sha256sum=76bc14366121efc8dbb487ab05bcc9d346b3b5ec0eaa76e46594cabbe51762c0;wasm-bindgen-futures-0.4.42.sha256sum=76bc14366121efc8dbb487ab05bcc9d346b3b5ec0eaa76e46594cabbe51762c0 \
    crate://crates.io/wasm-bindgen-macro-support/0.2.92;sha256sum=e94f17b526d0a461a191c78ea52bbce64071ed5c04c9ffe424dcb38f74171bb7;wasm-bindgen-macro-support-0.2.92.sha256sum=e94f17b526d0a461a191c78ea52bbce64071ed5c04c9ffe424dcb38f74171bb7 \
    crate://crates.io/wasm-bindgen-macro/0.2.92;sha256sum=a1f8823de937b71b9460c0c34e25f3da88250760bec0ebac694b49997550d726;wasm-bindgen-macro-0.2.92.sha256sum=a1f8823de937b71b9460c0c34e25f3da88250760bec0ebac694b49997550d726 \
    crate://crates.io/wasm-bindgen-shared/0.2.92;sha256sum=af190c94f2773fdb3729c55b007a722abb5384da03bc0986df4c289bf5567e96;wasm-bindgen-shared-0.2.92.sha256sum=af190c94f2773fdb3729c55b007a722abb5384da03bc0986df4c289bf5567e96 \
    crate://crates.io/wasm-bindgen/0.2.92;sha256sum=4be2531df63900aeb2bca0daaaddec08491ee64ceecbee5076636a3b026795a8;wasm-bindgen-0.2.92.sha256sum=4be2531df63900aeb2bca0daaaddec08491ee64ceecbee5076636a3b026795a8 \
    crate://crates.io/web-sys/0.3.69;sha256sum=77afa9a11836342370f4817622a2f0f418b134426d91a82dfb48f532d2ec13ef;web-sys-0.3.69.sha256sum=77afa9a11836342370f4817622a2f0f418b134426d91a82dfb48f532d2ec13ef \
    crate://crates.io/webpki/0.22.4;sha256sum=ed63aea5ce73d0ff405984102c42de94fc55a6b75765d621c65262469b3c9b53;webpki-0.22.4.sha256sum=ed63aea5ce73d0ff405984102c42de94fc55a6b75765d621c65262469b3c9b53 \
    crate://crates.io/which/4.4.2;sha256sum=87ba24419a2078cd2b0f2ede2691b6c66d8e47836da3b6db8265ebad47afbfc7;which-4.4.2.sha256sum=87ba24419a2078cd2b0f2ede2691b6c66d8e47836da3b6db8265ebad47afbfc7 \
    crate://crates.io/winapi-i686-pc-windows-gnu/0.4.0;sha256sum=ac3b87c63620426dd9b991e5ce0329eff545bccbbb34f3be09ff6fb6ab51b7b6;winapi-i686-pc-windows-gnu-0.4.0.sha256sum=ac3b87c63620426dd9b991e5ce0329eff545bccbbb34f3be09ff6fb6ab51b7b6 \
    crate://crates.io/winapi-util/0.1.8;sha256sum=4d4cc384e1e73b93bafa6fb4f1df8c41695c8a91cf9c4c64358067d15a7b6c6b;winapi-util-0.1.8.sha256sum=4d4cc384e1e73b93bafa6fb4f1df8c41695c8a91cf9c4c64358067d15a7b6c6b \
    crate://crates.io/winapi-x86_64-pc-windows-gnu/0.4.0;sha256sum=712e227841d057c1ee1cd2fb22fa7e5a5461ae8e48fa2ca79ec42cfc1931183f;winapi-x86_64-pc-windows-gnu-0.4.0.sha256sum=712e227841d057c1ee1cd2fb22fa7e5a5461ae8e48fa2ca79ec42cfc1931183f \
    crate://crates.io/winapi/0.3.9;sha256sum=5c839a674fcd7a98952e593242ea400abe93992746761e38641405d28b00f419;winapi-0.3.9.sha256sum=5c839a674fcd7a98952e593242ea400abe93992746761e38641405d28b00f419 \
    crate://crates.io/windows-core/0.52.0;sha256sum=33ab640c8d7e35bf8ba19b884ba838ceb4fba93a4e8c65a9059d08afcfc683d9;windows-core-0.52.0.sha256sum=33ab640c8d7e35bf8ba19b884ba838ceb4fba93a4e8c65a9059d08afcfc683d9 \
    crate://crates.io/windows-core/0.54.0;sha256sum=12661b9c89351d684a50a8a643ce5f608e20243b9fb84687800163429f161d65;windows-core-0.54.0.sha256sum=12661b9c89351d684a50a8a643ce5f608e20243b9fb84687800163429f161d65 \
    crate://crates.io/windows-result/0.1.2;sha256sum=5e383302e8ec8515204254685643de10811af0ed97ea37210dc26fb0032647f8;windows-result-0.1.2.sha256sum=5e383302e8ec8515204254685643de10811af0ed97ea37210dc26fb0032647f8 \
    crate://crates.io/windows-sys/0.45.0;sha256sum=75283be5efb2831d37ea142365f009c02ec203cd29a3ebecbc093d52315b66d0;windows-sys-0.45.0.sha256sum=75283be5efb2831d37ea142365f009c02ec203cd29a3ebecbc093d52315b66d0 \
    crate://crates.io/windows-sys/0.48.0;sha256sum=677d2418bec65e3338edb076e806bc1ec15693c5d0104683f2efe857f61056a9;windows-sys-0.48.0.sha256sum=677d2418bec65e3338edb076e806bc1ec15693c5d0104683f2efe857f61056a9 \
    crate://crates.io/windows-sys/0.52.0;sha256sum=282be5f36a8ce781fad8c8ae18fa3f9beff57ec1b52cb3de0789201425d9a33d;windows-sys-0.52.0.sha256sum=282be5f36a8ce781fad8c8ae18fa3f9beff57ec1b52cb3de0789201425d9a33d \
    crate://crates.io/windows-targets/0.42.2;sha256sum=8e5180c00cd44c9b1c88adb3693291f1cd93605ded80c250a75d472756b4d071;windows-targets-0.42.2.sha256sum=8e5180c00cd44c9b1c88adb3693291f1cd93605ded80c250a75d472756b4d071 \
    crate://crates.io/windows-targets/0.48.5;sha256sum=9a2fa6e2155d7247be68c096456083145c183cbbbc2764150dda45a87197940c;windows-targets-0.48.5.sha256sum=9a2fa6e2155d7247be68c096456083145c183cbbbc2764150dda45a87197940c \
    crate://crates.io/windows-targets/0.52.5;sha256sum=6f0713a46559409d202e70e28227288446bf7841d3211583a4b53e3f6d96e7eb;windows-targets-0.52.5.sha256sum=6f0713a46559409d202e70e28227288446bf7841d3211583a4b53e3f6d96e7eb \
    crate://crates.io/windows/0.52.0;sha256sum=e48a53791691ab099e5e2ad123536d0fff50652600abaf43bbf952894110d0be;windows-0.52.0.sha256sum=e48a53791691ab099e5e2ad123536d0fff50652600abaf43bbf952894110d0be \
    crate://crates.io/windows/0.54.0;sha256sum=9252e5725dbed82865af151df558e754e4a3c2c30818359eb17465f1346a1b49;windows-0.54.0.sha256sum=9252e5725dbed82865af151df558e754e4a3c2c30818359eb17465f1346a1b49 \
    crate://crates.io/windows_aarch64_gnullvm/0.42.2;sha256sum=597a5118570b68bc08d8d59125332c54f1ba9d9adeedeef5b99b02ba2b0698f8;windows_aarch64_gnullvm-0.42.2.sha256sum=597a5118570b68bc08d8d59125332c54f1ba9d9adeedeef5b99b02ba2b0698f8 \
    crate://crates.io/windows_aarch64_gnullvm/0.48.5;sha256sum=2b38e32f0abccf9987a4e3079dfb67dcd799fb61361e53e2882c3cbaf0d905d8;windows_aarch64_gnullvm-0.48.5.sha256sum=2b38e32f0abccf9987a4e3079dfb67dcd799fb61361e53e2882c3cbaf0d905d8 \
    crate://crates.io/windows_aarch64_gnullvm/0.52.5;sha256sum=7088eed71e8b8dda258ecc8bac5fb1153c5cffaf2578fc8ff5d61e23578d3263;windows_aarch64_gnullvm-0.52.5.sha256sum=7088eed71e8b8dda258ecc8bac5fb1153c5cffaf2578fc8ff5d61e23578d3263 \
    crate://crates.io/windows_aarch64_msvc/0.42.2;sha256sum=e08e8864a60f06ef0d0ff4ba04124db8b0fb3be5776a5cd47641e942e58c4d43;windows_aarch64_msvc-0.42.2.sha256sum=e08e8864a60f06ef0d0ff4ba04124db8b0fb3be5776a5cd47641e942e58c4d43 \
    crate://crates.io/windows_aarch64_msvc/0.48.5;sha256sum=dc35310971f3b2dbbf3f0690a219f40e2d9afcf64f9ab7cc1be722937c26b4bc;windows_aarch64_msvc-0.48.5.sha256sum=dc35310971f3b2dbbf3f0690a219f40e2d9afcf64f9ab7cc1be722937c26b4bc \
    crate://crates.io/windows_aarch64_msvc/0.52.5;sha256sum=9985fd1504e250c615ca5f281c3f7a6da76213ebd5ccc9561496568a2752afb6;windows_aarch64_msvc-0.52.5.sha256sum=9985fd1504e250c615ca5f281c3f7a6da76213ebd5ccc9561496568a2752afb6 \
    crate://crates.io/windows_i686_gnu/0.42.2;sha256sum=c61d927d8da41da96a81f029489353e68739737d3beca43145c8afec9a31a84f;windows_i686_gnu-0.42.2.sha256sum=c61d927d8da41da96a81f029489353e68739737d3beca43145c8afec9a31a84f \
    crate://crates.io/windows_i686_gnu/0.48.5;sha256sum=a75915e7def60c94dcef72200b9a8e58e5091744960da64ec734a6c6e9b3743e;windows_i686_gnu-0.48.5.sha256sum=a75915e7def60c94dcef72200b9a8e58e5091744960da64ec734a6c6e9b3743e \
    crate://crates.io/windows_i686_gnu/0.52.5;sha256sum=88ba073cf16d5372720ec942a8ccbf61626074c6d4dd2e745299726ce8b89670;windows_i686_gnu-0.52.5.sha256sum=88ba073cf16d5372720ec942a8ccbf61626074c6d4dd2e745299726ce8b89670 \
    crate://crates.io/windows_i686_gnullvm/0.52.5;sha256sum=87f4261229030a858f36b459e748ae97545d6f1ec60e5e0d6a3d32e0dc232ee9;windows_i686_gnullvm-0.52.5.sha256sum=87f4261229030a858f36b459e748ae97545d6f1ec60e5e0d6a3d32e0dc232ee9 \
    crate://crates.io/windows_i686_msvc/0.42.2;sha256sum=44d840b6ec649f480a41c8d80f9c65108b92d89345dd94027bfe06ac444d1060;windows_i686_msvc-0.42.2.sha256sum=44d840b6ec649f480a41c8d80f9c65108b92d89345dd94027bfe06ac444d1060 \
    crate://crates.io/windows_i686_msvc/0.48.5;sha256sum=8f55c233f70c4b27f66c523580f78f1004e8b5a8b659e05a4eb49d4166cca406;windows_i686_msvc-0.48.5.sha256sum=8f55c233f70c4b27f66c523580f78f1004e8b5a8b659e05a4eb49d4166cca406 \
    crate://crates.io/windows_i686_msvc/0.52.5;sha256sum=db3c2bf3d13d5b658be73463284eaf12830ac9a26a90c717b7f771dfe97487bf;windows_i686_msvc-0.52.5.sha256sum=db3c2bf3d13d5b658be73463284eaf12830ac9a26a90c717b7f771dfe97487bf \
    crate://crates.io/windows_x86_64_gnu/0.42.2;sha256sum=8de912b8b8feb55c064867cf047dda097f92d51efad5b491dfb98f6bbb70cb36;windows_x86_64_gnu-0.42.2.sha256sum=8de912b8b8feb55c064867cf047dda097f92d51efad5b491dfb98f6bbb70cb36 \
    crate://crates.io/windows_x86_64_gnu/0.48.5;sha256sum=53d40abd2583d23e4718fddf1ebec84dbff8381c07cae67ff7768bbf19c6718e;windows_x86_64_gnu-0.48.5.sha256sum=53d40abd2583d23e4718fddf1ebec84dbff8381c07cae67ff7768bbf19c6718e \
    crate://crates.io/windows_x86_64_gnu/0.52.5;sha256sum=4e4246f76bdeff09eb48875a0fd3e2af6aada79d409d33011886d3e1581517d9;windows_x86_64_gnu-0.52.5.sha256sum=4e4246f76bdeff09eb48875a0fd3e2af6aada79d409d33011886d3e1581517d9 \
    crate://crates.io/windows_x86_64_gnullvm/0.42.2;sha256sum=26d41b46a36d453748aedef1486d5c7a85db22e56aff34643984ea85514e94a3;windows_x86_64_gnullvm-0.42.2.sha256sum=26d41b46a36d453748aedef1486d5c7a85db22e56aff34643984ea85514e94a3 \
    crate://crates.io/windows_x86_64_gnullvm/0.48.5;sha256sum=0b7b52767868a23d5bab768e390dc5f5c55825b6d30b86c844ff2dc7414044cc;windows_x86_64_gnullvm-0.48.5.sha256sum=0b7b52767868a23d5bab768e390dc5f5c55825b6d30b86c844ff2dc7414044cc \
    crate://crates.io/windows_x86_64_gnullvm/0.52.5;sha256sum=852298e482cd67c356ddd9570386e2862b5673c85bd5f88df9ab6802b334c596;windows_x86_64_gnullvm-0.52.5.sha256sum=852298e482cd67c356ddd9570386e2862b5673c85bd5f88df9ab6802b334c596 \
    crate://crates.io/windows_x86_64_msvc/0.42.2;sha256sum=9aec5da331524158c6d1a4ac0ab1541149c0b9505fde06423b02f5ef0106b9f0;windows_x86_64_msvc-0.42.2.sha256sum=9aec5da331524158c6d1a4ac0ab1541149c0b9505fde06423b02f5ef0106b9f0 \
    crate://crates.io/windows_x86_64_msvc/0.48.5;sha256sum=ed94fce61571a4006852b7389a063ab983c02eb1bb37b47f8272ce92d06d9538;windows_x86_64_msvc-0.48.5.sha256sum=ed94fce61571a4006852b7389a063ab983c02eb1bb37b47f8272ce92d06d9538 \
    crate://crates.io/windows_x86_64_msvc/0.52.5;sha256sum=bec47e5bfd1bff0eeaf6d8b485cc1074891a197ab4225d504cb7a1ab88b02bf0;windows_x86_64_msvc-0.52.5.sha256sum=bec47e5bfd1bff0eeaf6d8b485cc1074891a197ab4225d504cb7a1ab88b02bf0 \
    crate://crates.io/winnow/0.5.40;sha256sum=f593a95398737aeed53e489c785df13f3618e41dbcd6718c6addbf1395aa6876;winnow-0.5.40.sha256sum=f593a95398737aeed53e489c785df13f3618e41dbcd6718c6addbf1395aa6876 \
    crate://crates.io/winnow/0.6.13;sha256sum=59b5e5f6c299a3c7890b876a2a587f3115162487e704907d9b6cd29473052ba1;winnow-0.6.13.sha256sum=59b5e5f6c299a3c7890b876a2a587f3115162487e704907d9b6cd29473052ba1 \
    crate://crates.io/write16/1.0.0;sha256sum=d1890f4022759daae28ed4fe62859b1236caebfc61ede2f63ed4e695f3f6d936;write16-1.0.0.sha256sum=d1890f4022759daae28ed4fe62859b1236caebfc61ede2f63ed4e695f3f6d936 \
    crate://crates.io/writeable/0.5.5;sha256sum=1e9df38ee2d2c3c5948ea468a8406ff0db0b29ae1ffde1bcf20ef305bcc95c51;writeable-0.5.5.sha256sum=1e9df38ee2d2c3c5948ea468a8406ff0db0b29ae1ffde1bcf20ef305bcc95c51 \
    crate://crates.io/yoke-derive/0.7.4;sha256sum=28cc31741b18cb6f1d5ff12f5b7523e3d6eb0852bbbad19d73905511d9849b95;yoke-derive-0.7.4.sha256sum=28cc31741b18cb6f1d5ff12f5b7523e3d6eb0852bbbad19d73905511d9849b95 \
    crate://crates.io/yoke/0.7.4;sha256sum=6c5b1314b079b0930c31e3af543d8ee1757b1951ae1e1565ec704403a7240ca5;yoke-0.7.4.sha256sum=6c5b1314b079b0930c31e3af543d8ee1757b1951ae1e1565ec704403a7240ca5 \
    crate://crates.io/zerocopy-derive/0.7.34;sha256sum=15e934569e47891f7d9411f1a451d947a60e000ab3bd24fbb970f000387d1b3b;zerocopy-derive-0.7.34.sha256sum=15e934569e47891f7d9411f1a451d947a60e000ab3bd24fbb970f000387d1b3b \
    crate://crates.io/zerocopy/0.7.34;sha256sum=ae87e3fcd617500e5d106f0380cf7b77f3c6092aae37191433159dda23cfb087;zerocopy-0.7.34.sha256sum=ae87e3fcd617500e5d106f0380cf7b77f3c6092aae37191433159dda23cfb087 \
    crate://crates.io/zerofrom-derive/0.1.4;sha256sum=0ea7b4a3637ea8669cedf0f1fd5c286a17f3de97b8dd5a70a6c167a1730e63a5;zerofrom-derive-0.1.4.sha256sum=0ea7b4a3637ea8669cedf0f1fd5c286a17f3de97b8dd5a70a6c167a1730e63a5 \
    crate://crates.io/zerofrom/0.1.4;sha256sum=91ec111ce797d0e0784a1116d0ddcdbea84322cd79e5d5ad173daeba4f93ab55;zerofrom-0.1.4.sha256sum=91ec111ce797d0e0784a1116d0ddcdbea84322cd79e5d5ad173daeba4f93ab55 \
    crate://crates.io/zeroize/1.8.1;sha256sum=ced3678a2879b30306d323f4542626697a464a97c0a07c9aebf7ebca65cd4dde;zeroize-1.8.1.sha256sum=ced3678a2879b30306d323f4542626697a464a97c0a07c9aebf7ebca65cd4dde \
    crate://crates.io/zerovec-derive/0.10.2;sha256sum=97cf56601ee5052b4417d90c8755c6683473c926039908196cf35d99f893ebe7;zerovec-derive-0.10.2.sha256sum=97cf56601ee5052b4417d90c8755c6683473c926039908196cf35d99f893ebe7 \
    crate://crates.io/zerovec/0.10.2;sha256sum=bb2cc8827d6c0994478a15c53f374f46fbd41bea663d809b14744bc42e6b109c;zerovec-0.10.2.sha256sum=bb2cc8827d6c0994478a15c53f374f46fbd41bea663d809b14744bc42e6b109c \
"

# FIXME: update generateme with the real MD5 of the license file
LIC_FILES_CHKSUM = " \
    file://LICENSE;md5=98b2b0c9a6081259c441045ca68b640f \
"

SUMMARY = "An open source client library for Spotify, with support for Spotify Connect"
HOMEPAGE = "https://github.com/librespot-org/librespot"
LICENSE = "MIT"

# includes this file if it exists but does not fail
# this is useful for anything you may want to override from
# what cargo-bitbake generates.
include librespot-${PV}.inc
include librespot.inc
