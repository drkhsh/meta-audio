# Auto-Generated by cargo-bitbake 0.3.16-alpha.0
#
inherit cargo

# If this is git based prefer versioned ones if they exist
# DEFAULT_PREFERENCE = "-1"

# how to get camilladsp could be as easy as but default to a git checkout:
# SRC_URI += "crate://crates.io/camilladsp/2.0.3"
SRC_URI += "git://github.com/HEnquist/camilladsp;protocol=https;nobranch=1"
SRCREV = "76aa55dddc237daa0477bfea45df8bfba6e22cc1"
S = "${WORKDIR}/git"
CARGO_SRC_DIR = ""


# please note if you have entries that do not begin with crate://
# you must change them to how that package can be fetched
SRC_URI += " \
    crate://crates.io/adler2/2.0.0;sha256sum=512761e0bb2578dd7380c6baaa0f4ce03e84f95e960231d1dec8bf4d7d6e2627;adler2-2.0.0.sha256sum=512761e0bb2578dd7380c6baaa0f4ce03e84f95e960231d1dec8bf4d7d6e2627 \
    crate://crates.io/aho-corasick/0.5.3;sha256sum=ca972c2ea5f742bfce5687b9aef75506a764f61d37f8f649047846a9686ddb66;aho-corasick-0.5.3.sha256sum=ca972c2ea5f742bfce5687b9aef75506a764f61d37f8f649047846a9686ddb66 \
    crate://crates.io/aho-corasick/1.1.3;sha256sum=8e60d3430d3a69478ad0993f19238d2df97c507009a52b3c10addcd7f6bcb916;aho-corasick-1.1.3.sha256sum=8e60d3430d3a69478ad0993f19238d2df97c507009a52b3c10addcd7f6bcb916 \
    crate://crates.io/alsa-sys/0.3.1;sha256sum=db8fee663d06c4e303404ef5f40488a53e062f89ba8bfed81f42325aafad1527;alsa-sys-0.3.1.sha256sum=db8fee663d06c4e303404ef5f40488a53e062f89ba8bfed81f42325aafad1527 \
    crate://crates.io/alsa/0.6.0;sha256sum=5915f52fe2cf65e83924d037b6c5290b7cee097c6b5c8700746e6168a343fd6b;alsa-0.6.0.sha256sum=5915f52fe2cf65e83924d037b6c5290b7cee097c6b5c8700746e6168a343fd6b \
    crate://crates.io/alsa/0.8.1;sha256sum=ce34de545ad29bcc00cb1b87a94c132256dcf83aa7eeb9674482568405a6ff0a;alsa-0.8.1.sha256sum=ce34de545ad29bcc00cb1b87a94c132256dcf83aa7eeb9674482568405a6ff0a \
    crate://crates.io/android-tzdata/0.1.1;sha256sum=e999941b234f3131b00bc13c22d06e8c5ff726d1b6318ac7eb276997bbb4fef0;android-tzdata-0.1.1.sha256sum=e999941b234f3131b00bc13c22d06e8c5ff726d1b6318ac7eb276997bbb4fef0 \
    crate://crates.io/android_system_properties/0.1.5;sha256sum=819e7219dbd41043ac279b19830f2efc897156490d7fd6ea916720117ee66311;android_system_properties-0.1.5.sha256sum=819e7219dbd41043ac279b19830f2efc897156490d7fd6ea916720117ee66311 \
    crate://crates.io/ansi_term/0.12.1;sha256sum=d52a9bb7ec0cf484c551830a7ce27bd20d67eac647e1befb56b0be4ee39a55d2;ansi_term-0.12.1.sha256sum=d52a9bb7ec0cf484c551830a7ce27bd20d67eac647e1befb56b0be4ee39a55d2 \
    crate://crates.io/anyhow/1.0.86;sha256sum=b3d1d046238990b9cf5bcde22a3fb3584ee5cf65fb2765f454ed428c7a0063da;anyhow-1.0.86.sha256sum=b3d1d046238990b9cf5bcde22a3fb3584ee5cf65fb2765f454ed428c7a0063da \
    crate://crates.io/async-broadcast/0.5.1;sha256sum=7c48ccdbf6ca6b121e0f586cbc0e73ae440e56c67c30fa0873b4e110d9c26d2b;async-broadcast-0.5.1.sha256sum=7c48ccdbf6ca6b121e0f586cbc0e73ae440e56c67c30fa0873b4e110d9c26d2b \
    crate://crates.io/async-channel/2.3.1;sha256sum=89b47800b0be77592da0afd425cc03468052844aff33b84e33cc696f64e77b6a;async-channel-2.3.1.sha256sum=89b47800b0be77592da0afd425cc03468052844aff33b84e33cc696f64e77b6a \
    crate://crates.io/async-executor/1.13.0;sha256sum=d7ebdfa2ebdab6b1760375fa7d6f382b9f486eac35fc994625a00e89280bdbb7;async-executor-1.13.0.sha256sum=d7ebdfa2ebdab6b1760375fa7d6f382b9f486eac35fc994625a00e89280bdbb7 \
    crate://crates.io/async-fs/1.6.0;sha256sum=279cf904654eeebfa37ac9bb1598880884924aab82e290aa65c9e77a0e142e06;async-fs-1.6.0.sha256sum=279cf904654eeebfa37ac9bb1598880884924aab82e290aa65c9e77a0e142e06 \
    crate://crates.io/async-io/1.13.0;sha256sum=0fc5b45d93ef0529756f812ca52e44c221b35341892d3dcc34132ac02f3dd2af;async-io-1.13.0.sha256sum=0fc5b45d93ef0529756f812ca52e44c221b35341892d3dcc34132ac02f3dd2af \
    crate://crates.io/async-io/2.3.4;sha256sum=444b0228950ee6501b3568d3c93bf1176a1fdbc3b758dcd9475046d30f4dc7e8;async-io-2.3.4.sha256sum=444b0228950ee6501b3568d3c93bf1176a1fdbc3b758dcd9475046d30f4dc7e8 \
    crate://crates.io/async-lock/2.8.0;sha256sum=287272293e9d8c41773cec55e365490fe034813a2f172f502d6ddcf75b2f582b;async-lock-2.8.0.sha256sum=287272293e9d8c41773cec55e365490fe034813a2f172f502d6ddcf75b2f582b \
    crate://crates.io/async-lock/3.4.0;sha256sum=ff6e472cdea888a4bd64f342f09b3f50e1886d32afe8df3d663c01140b811b18;async-lock-3.4.0.sha256sum=ff6e472cdea888a4bd64f342f09b3f50e1886d32afe8df3d663c01140b811b18 \
    crate://crates.io/async-process/1.8.1;sha256sum=ea6438ba0a08d81529c69b36700fa2f95837bfe3e776ab39cde9c14d9149da88;async-process-1.8.1.sha256sum=ea6438ba0a08d81529c69b36700fa2f95837bfe3e776ab39cde9c14d9149da88 \
    crate://crates.io/async-recursion/1.1.1;sha256sum=3b43422f69d8ff38f95f1b2bb76517c91589a924d1559a0e935d7c8ce0274c11;async-recursion-1.1.1.sha256sum=3b43422f69d8ff38f95f1b2bb76517c91589a924d1559a0e935d7c8ce0274c11 \
    crate://crates.io/async-signal/0.2.10;sha256sum=637e00349800c0bdf8bfc21ebbc0b6524abea702b0da4168ac00d070d0c0b9f3;async-signal-0.2.10.sha256sum=637e00349800c0bdf8bfc21ebbc0b6524abea702b0da4168ac00d070d0c0b9f3 \
    crate://crates.io/async-task/4.7.1;sha256sum=8b75356056920673b02621b35afd0f7dda9306d03c79a30f5c56c44cf256e3de;async-task-4.7.1.sha256sum=8b75356056920673b02621b35afd0f7dda9306d03c79a30f5c56c44cf256e3de \
    crate://crates.io/async-trait/0.1.81;sha256sum=6e0c28dcc82d7c8ead5cb13beb15405b57b8546e93215673ff8ca0349a028107;async-trait-0.1.81.sha256sum=6e0c28dcc82d7c8ead5cb13beb15405b57b8546e93215673ff8ca0349a028107 \
    crate://crates.io/atomic-waker/1.1.2;sha256sum=1505bd5d3d116872e7271a6d4e16d81d0c8570876c8de68093a09ac269d8aac0;atomic-waker-1.1.2.sha256sum=1505bd5d3d116872e7271a6d4e16d81d0c8570876c8de68093a09ac269d8aac0 \
    crate://crates.io/atty/0.2.14;sha256sum=d9b39be18770d11421cdb1b9947a45dd3f37e93092cbf377614828a319d5fee8;atty-0.2.14.sha256sum=d9b39be18770d11421cdb1b9947a45dd3f37e93092cbf377614828a319d5fee8 \
    crate://crates.io/autocfg/1.3.0;sha256sum=0c4b4d0bd25bd0b74681c0ad21497610ce1b7c91b1022cd21c80c6fbdd9476b0;autocfg-1.3.0.sha256sum=0c4b4d0bd25bd0b74681c0ad21497610ce1b7c91b1022cd21c80c6fbdd9476b0 \
    crate://crates.io/bindgen/0.69.4;sha256sum=a00dc851838a2120612785d195287475a3ac45514741da670b735818822129a0;bindgen-0.69.4.sha256sum=a00dc851838a2120612785d195287475a3ac45514741da670b735818822129a0 \
    crate://crates.io/bitflags/1.3.2;sha256sum=bef38d45163c2f1dde094a7dfd33ccf595c92905c8f8f4fdc18d06fb1037718a;bitflags-1.3.2.sha256sum=bef38d45163c2f1dde094a7dfd33ccf595c92905c8f8f4fdc18d06fb1037718a \
    crate://crates.io/bitflags/2.6.0;sha256sum=b048fb63fd8b5923fc5aa7b340d8e156aec7ec02f0c78fa8a6ddc2613f6f71de;bitflags-2.6.0.sha256sum=b048fb63fd8b5923fc5aa7b340d8e156aec7ec02f0c78fa8a6ddc2613f6f71de \
    crate://crates.io/block-buffer/0.10.4;sha256sum=3078c7629b62d3f0439517fa394996acacc5cbc91c5a20d8c658e77abd503a71;block-buffer-0.10.4.sha256sum=3078c7629b62d3f0439517fa394996acacc5cbc91c5a20d8c658e77abd503a71 \
    crate://crates.io/blocking/1.6.1;sha256sum=703f41c54fc768e63e091340b424302bb1c29ef4aa0c7f10fe849dfb114d29ea;blocking-1.6.1.sha256sum=703f41c54fc768e63e091340b424302bb1c29ef4aa0c7f10fe849dfb114d29ea \
    crate://crates.io/bumpalo/3.16.0;sha256sum=79296716171880943b8470b5f8d03aa55eb2e645a4874bdbb28adb49162e012c;bumpalo-3.16.0.sha256sum=79296716171880943b8470b5f8d03aa55eb2e645a4874bdbb28adb49162e012c \
    crate://crates.io/byteorder/1.5.0;sha256sum=1fd0f2584146f6f2ef48085050886acf353beff7305ebd1ae69500e27c67f64b;byteorder-1.5.0.sha256sum=1fd0f2584146f6f2ef48085050886acf353beff7305ebd1ae69500e27c67f64b \
    crate://crates.io/bytes/1.7.1;sha256sum=8318a53db07bb3f8dca91a600466bdb3f2eaadeedfdbcf02e1accbad9271ba50;bytes-1.7.1.sha256sum=8318a53db07bb3f8dca91a600466bdb3f2eaadeedfdbcf02e1accbad9271ba50 \
    crate://crates.io/bzip2-sys/0.1.11+1.0.8;sha256sum=736a955f3fa7875102d57c82b8cac37ec45224a07fd32d58f9f7a186b6cd4cdc;bzip2-sys-0.1.11+1.0.8.sha256sum=736a955f3fa7875102d57c82b8cac37ec45224a07fd32d58f9f7a186b6cd4cdc \
    crate://crates.io/bzip2/0.4.4;sha256sum=bdb116a6ef3f6c3698828873ad02c3014b3c85cadb88496095628e3ef1e347f8;bzip2-0.4.4.sha256sum=bdb116a6ef3f6c3698828873ad02c3014b3c85cadb88496095628e3ef1e347f8 \
    crate://crates.io/cast/0.3.0;sha256sum=37b2a672a2cb129a2e41c10b1224bb368f9f37a2b16b612598138befd7b37eb5;cast-0.3.0.sha256sum=37b2a672a2cb129a2e41c10b1224bb368f9f37a2b16b612598138befd7b37eb5 \
    crate://crates.io/cc/1.1.14;sha256sum=50d2eb3cd3d1bf4529e31c215ee6f93ec5a3d536d9f578f93d9d33ee19562932;cc-1.1.14.sha256sum=50d2eb3cd3d1bf4529e31c215ee6f93ec5a3d536d9f578f93d9d33ee19562932 \
    crate://crates.io/cesu8/1.1.0;sha256sum=6d43a04d8753f35258c91f8ec639f792891f748a1edbd759cf1dcea3382ad83c;cesu8-1.1.0.sha256sum=6d43a04d8753f35258c91f8ec639f792891f748a1edbd759cf1dcea3382ad83c \
    crate://crates.io/cexpr/0.6.0;sha256sum=6fac387a98bb7c37292057cffc56d62ecb629900026402633ae9160df93a8766;cexpr-0.6.0.sha256sum=6fac387a98bb7c37292057cffc56d62ecb629900026402633ae9160df93a8766 \
    crate://crates.io/cfg-if/1.0.0;sha256sum=baf1de4339761588bc0619e3cbc0120ee582ebb74b53b4efbf79117bd2da40fd;cfg-if-1.0.0.sha256sum=baf1de4339761588bc0619e3cbc0120ee582ebb74b53b4efbf79117bd2da40fd \
    crate://crates.io/chrono/0.2.25;sha256sum=9213f7cd7c27e95c2b57c49f0e69b1ea65b27138da84a170133fd21b07659c00;chrono-0.2.25.sha256sum=9213f7cd7c27e95c2b57c49f0e69b1ea65b27138da84a170133fd21b07659c00 \
    crate://crates.io/chrono/0.4.38;sha256sum=a21f936df1771bf62b77f047b726c4625ff2e8aa607c01ec06e5a05bd8463401;chrono-0.4.38.sha256sum=a21f936df1771bf62b77f047b726c4625ff2e8aa607c01ec06e5a05bd8463401 \
    crate://crates.io/circular-queue/0.2.6;sha256sum=1d34327ead1c743a10db339de35fb58957564b99d248a67985c55638b22c59b5;circular-queue-0.2.6.sha256sum=1d34327ead1c743a10db339de35fb58957564b99d248a67985c55638b22c59b5 \
    crate://crates.io/clang-sys/1.8.1;sha256sum=0b023947811758c97c59bf9d1c188fd619ad4718dcaa767947df1cadb14f39f4;clang-sys-1.8.1.sha256sum=0b023947811758c97c59bf9d1c188fd619ad4718dcaa767947df1cadb14f39f4 \
    crate://crates.io/clap/2.34.0;sha256sum=a0610544180c38b88101fecf2dd634b174a62eef6946f84dfc6a7127512b381c;clap-2.34.0.sha256sum=a0610544180c38b88101fecf2dd634b174a62eef6946f84dfc6a7127512b381c \
    crate://crates.io/combine/4.6.7;sha256sum=ba5a308b75df32fe02788e748662718f03fde005016435c444eea572398219fd;combine-4.6.7.sha256sum=ba5a308b75df32fe02788e748662718f03fde005016435c444eea572398219fd \
    crate://crates.io/concurrent-queue/2.5.0;sha256sum=4ca0197aee26d1ae37445ee532fefce43251d24cc7c166799f4d46817f1d3973;concurrent-queue-2.5.0.sha256sum=4ca0197aee26d1ae37445ee532fefce43251d24cc7c166799f4d46817f1d3973 \
    crate://crates.io/core-foundation-sys/0.8.7;sha256sum=773648b94d0e5d620f64f280777445740e61fe701025087ec8b57f45c791888b;core-foundation-sys-0.8.7.sha256sum=773648b94d0e5d620f64f280777445740e61fe701025087ec8b57f45c791888b \
    crate://crates.io/core-foundation/0.9.4;sha256sum=91e195e091a93c46f7102ec7818a2aa394e1e1771c3ab4825963fa03e45afb8f;core-foundation-0.9.4.sha256sum=91e195e091a93c46f7102ec7818a2aa394e1e1771c3ab4825963fa03e45afb8f \
    crate://crates.io/coreaudio-rs/0.10.0;sha256sum=11894b20ebfe1ff903cbdc52259693389eea03b94918a2def2c30c3bf227ad88;coreaudio-rs-0.10.0.sha256sum=11894b20ebfe1ff903cbdc52259693389eea03b94918a2def2c30c3bf227ad88 \
    crate://crates.io/coreaudio-rs/0.11.3;sha256sum=321077172d79c662f64f5071a03120748d5bb652f5231570141be24cfcd2bace;coreaudio-rs-0.11.3.sha256sum=321077172d79c662f64f5071a03120748d5bb652f5231570141be24cfcd2bace \
    crate://crates.io/coreaudio-sys/0.2.15;sha256sum=7f01585027057ff5f0a5bf276174ae4c1594a2c5bde93d5f46a016d76270f5a9;coreaudio-sys-0.2.15.sha256sum=7f01585027057ff5f0a5bf276174ae4c1594a2c5bde93d5f46a016d76270f5a9 \
    crate://crates.io/cpal/0.13.5;sha256sum=74117836a5124f3629e4b474eed03e479abaf98988b4bb317e29f08cfe0e4116;cpal-0.13.5.sha256sum=74117836a5124f3629e4b474eed03e479abaf98988b4bb317e29f08cfe0e4116 \
    crate://crates.io/cpufeatures/0.2.13;sha256sum=51e852e6dc9a5bed1fae92dd2375037bf2b768725bf3be87811edee3249d09ad;cpufeatures-0.2.13.sha256sum=51e852e6dc9a5bed1fae92dd2375037bf2b768725bf3be87811edee3249d09ad \
    crate://crates.io/crc32fast/1.4.2;sha256sum=a97769d94ddab943e4510d138150169a2758b5ef3eb191a9ee688de3e23ef7b3;crc32fast-1.4.2.sha256sum=a97769d94ddab943e4510d138150169a2758b5ef3eb191a9ee688de3e23ef7b3 \
    crate://crates.io/criterion-plot/0.4.5;sha256sum=2673cc8207403546f45f5fd319a974b1e6983ad1a3ee7e6041650013be041876;criterion-plot-0.4.5.sha256sum=2673cc8207403546f45f5fd319a974b1e6983ad1a3ee7e6041650013be041876 \
    crate://crates.io/criterion/0.3.6;sha256sum=b01d6de93b2b6c65e17c634a26653a29d107b3c98c607c765bf38d041531cd8f;criterion-0.3.6.sha256sum=b01d6de93b2b6c65e17c634a26653a29d107b3c98c607c765bf38d041531cd8f \
    crate://crates.io/crossbeam-channel/0.5.13;sha256sum=33480d6946193aa8033910124896ca395333cae7e2d1113d1fef6c3272217df2;crossbeam-channel-0.5.13.sha256sum=33480d6946193aa8033910124896ca395333cae7e2d1113d1fef6c3272217df2 \
    crate://crates.io/crossbeam-deque/0.8.5;sha256sum=613f8cc01fe9cf1a3eb3d7f488fd2fa8388403e97039e2f73692932e291a770d;crossbeam-deque-0.8.5.sha256sum=613f8cc01fe9cf1a3eb3d7f488fd2fa8388403e97039e2f73692932e291a770d \
    crate://crates.io/crossbeam-epoch/0.9.18;sha256sum=5b82ac4a3c2ca9c3460964f020e1402edd5753411d7737aa39c3714ad1b5420e;crossbeam-epoch-0.9.18.sha256sum=5b82ac4a3c2ca9c3460964f020e1402edd5753411d7737aa39c3714ad1b5420e \
    crate://crates.io/crossbeam-queue/0.3.11;sha256sum=df0346b5d5e76ac2fe4e327c5fd1118d6be7c51dfb18f9b7922923f287471e35;crossbeam-queue-0.3.11.sha256sum=df0346b5d5e76ac2fe4e327c5fd1118d6be7c51dfb18f9b7922923f287471e35 \
    crate://crates.io/crossbeam-utils/0.8.20;sha256sum=22ec99545bb0ed0ea7bb9b8e1e9122ea386ff8a48c0922e43f36d45ab09e0e80;crossbeam-utils-0.8.20.sha256sum=22ec99545bb0ed0ea7bb9b8e1e9122ea386ff8a48c0922e43f36d45ab09e0e80 \
    crate://crates.io/crypto-common/0.1.6;sha256sum=1bfb12502f3fc46cca1bb51ac28df9d618d813cdc3d2f25b9fe775a34af26bb3;crypto-common-0.1.6.sha256sum=1bfb12502f3fc46cca1bb51ac28df9d618d813cdc3d2f25b9fe775a34af26bb3 \
    crate://crates.io/csv-core/0.1.11;sha256sum=5efa2b3d7902f4b634a20cae3c9c4e6209dc4779feb6863329607560143efa70;csv-core-0.1.11.sha256sum=5efa2b3d7902f4b634a20cae3c9c4e6209dc4779feb6863329607560143efa70 \
    crate://crates.io/csv/1.3.0;sha256sum=ac574ff4d437a7b5ad237ef331c17ccca63c46479e5b5453eb8e10bb99a759fe;csv-1.3.0.sha256sum=ac574ff4d437a7b5ad237ef331c17ccca63c46479e5b5453eb8e10bb99a759fe \
    crate://crates.io/darling/0.13.4;sha256sum=a01d95850c592940db9b8194bc39f4bc0e89dee5c4265e4b1807c34a9aba453c;darling-0.13.4.sha256sum=a01d95850c592940db9b8194bc39f4bc0e89dee5c4265e4b1807c34a9aba453c \
    crate://crates.io/darling_core/0.13.4;sha256sum=859d65a907b6852c9361e3185c862aae7fafd2887876799fa55f5f99dc40d610;darling_core-0.13.4.sha256sum=859d65a907b6852c9361e3185c862aae7fafd2887876799fa55f5f99dc40d610 \
    crate://crates.io/darling_macro/0.13.4;sha256sum=9c972679f83bdf9c42bd905396b6c3588a843a17f0f16dfcfa3e2c5d57441835;darling_macro-0.13.4.sha256sum=9c972679f83bdf9c42bd905396b6c3588a843a17f0f16dfcfa3e2c5d57441835 \
    crate://crates.io/data-encoding/2.6.0;sha256sum=e8566979429cf69b49a5c740c60791108e86440e8be149bbea4fe54d2c32d6e2;data-encoding-2.6.0.sha256sum=e8566979429cf69b49a5c740c60791108e86440e8be149bbea4fe54d2c32d6e2 \
    crate://crates.io/derivative/2.2.0;sha256sum=fcc3dd5e9e9c0b295d6e1e4d811fb6f157d5ffd784b8d202fc62eac8035a770b;derivative-2.2.0.sha256sum=fcc3dd5e9e9c0b295d6e1e4d811fb6f157d5ffd784b8d202fc62eac8035a770b \
    crate://crates.io/digest/0.10.7;sha256sum=9ed9a281f7bc9b7576e61468ba615a66a5c8cfdff42420a70aa82701a3b1e292;digest-0.10.7.sha256sum=9ed9a281f7bc9b7576e61468ba615a66a5c8cfdff42420a70aa82701a3b1e292 \
    crate://crates.io/dispatch/0.2.0;sha256sum=bd0c93bb4b0c6d9b77f4435b0ae98c24d17f1c45b2ff844c6151a07256ca923b;dispatch-0.2.0.sha256sum=bd0c93bb4b0c6d9b77f4435b0ae98c24d17f1c45b2ff844c6151a07256ca923b \
    crate://crates.io/either/1.13.0;sha256sum=60b1af1c220855b6ceac025d3f6ecdd2b7c4894bfe9cd9bda4fbb4bc7c0d4cf0;either-1.13.0.sha256sum=60b1af1c220855b6ceac025d3f6ecdd2b7c4894bfe9cd9bda4fbb4bc7c0d4cf0 \
    crate://crates.io/enumflags2/0.7.10;sha256sum=d232db7f5956f3f14313dc2f87985c58bd2c695ce124c8cdd984e08e15ac133d;enumflags2-0.7.10.sha256sum=d232db7f5956f3f14313dc2f87985c58bd2c695ce124c8cdd984e08e15ac133d \
    crate://crates.io/enumflags2_derive/0.7.10;sha256sum=de0d48a183585823424a4ce1aa132d174a6a81bd540895822eb4c8373a8e49e8;enumflags2_derive-0.7.10.sha256sum=de0d48a183585823424a4ce1aa132d174a6a81bd540895822eb4c8373a8e49e8 \
    crate://crates.io/equivalent/1.0.1;sha256sum=5443807d6dff69373d433ab9ef5378ad8df50ca6298caf15de6e52e24aaf54d5;equivalent-1.0.1.sha256sum=5443807d6dff69373d433ab9ef5378ad8df50ca6298caf15de6e52e24aaf54d5 \
    crate://crates.io/errno/0.3.9;sha256sum=534c5cf6194dfab3db3242765c03bbe257cf92f22b38f6bc0c58d59108a820ba;errno-0.3.9.sha256sum=534c5cf6194dfab3db3242765c03bbe257cf92f22b38f6bc0c58d59108a820ba \
    crate://crates.io/event-listener-strategy/0.5.2;sha256sum=0f214dc438f977e6d4e3500aaa277f5ad94ca83fbbd9b1a15713ce2344ccc5a1;event-listener-strategy-0.5.2.sha256sum=0f214dc438f977e6d4e3500aaa277f5ad94ca83fbbd9b1a15713ce2344ccc5a1 \
    crate://crates.io/event-listener/2.5.3;sha256sum=0206175f82b8d6bf6652ff7d71a1e27fd2e4efde587fd368662814d6ec1d9ce0;event-listener-2.5.3.sha256sum=0206175f82b8d6bf6652ff7d71a1e27fd2e4efde587fd368662814d6ec1d9ce0 \
    crate://crates.io/event-listener/3.1.0;sha256sum=d93877bcde0eb80ca09131a08d23f0a5c18a620b01db137dba666d18cd9b30c2;event-listener-3.1.0.sha256sum=d93877bcde0eb80ca09131a08d23f0a5c18a620b01db137dba666d18cd9b30c2 \
    crate://crates.io/event-listener/5.3.1;sha256sum=6032be9bd27023a771701cc49f9f053c751055f71efb2e0ae5c15809093675ba;event-listener-5.3.1.sha256sum=6032be9bd27023a771701cc49f9f053c751055f71efb2e0ae5c15809093675ba \
    crate://crates.io/fastrand/1.9.0;sha256sum=e51093e27b0797c359783294ca4f0a911c270184cb10f85783b118614a1501be;fastrand-1.9.0.sha256sum=e51093e27b0797c359783294ca4f0a911c270184cb10f85783b118614a1501be \
    crate://crates.io/fastrand/2.1.1;sha256sum=e8c02a5121d4ea3eb16a80748c74f5549a5665e4c21333c6098f283870fbdea6;fastrand-2.1.1.sha256sum=e8c02a5121d4ea3eb16a80748c74f5549a5665e4c21333c6098f283870fbdea6 \
    crate://crates.io/fftw-src/0.3.3;sha256sum=c08962470ab0e91e74ec7d338c8731476c28ed4e503a3080b0f001692e395a7c;fftw-src-0.3.3.sha256sum=c08962470ab0e91e74ec7d338c8731476c28ed4e503a3080b0f001692e395a7c \
    crate://crates.io/fftw-sys/0.6.0;sha256sum=e8e3951d695cc2f17610cd041e87ebc15078d1af5eb8c6be77921381fc98b3fd;fftw-sys-0.6.0.sha256sum=e8e3951d695cc2f17610cd041e87ebc15078d1af5eb8c6be77921381fc98b3fd \
    crate://crates.io/fftw/0.7.0;sha256sum=9dc6a84bbb6bac64521bfb5a544701ce118f329d550cf9b9054d1954fe61adef;fftw-0.7.0.sha256sum=9dc6a84bbb6bac64521bfb5a544701ce118f329d550cf9b9054d1954fe61adef \
    crate://crates.io/flate2/1.0.32;sha256sum=9c0596c1eac1f9e04ed902702e9878208b336edc9d6fddc8a48387349bab3666;flate2-1.0.32.sha256sum=9c0596c1eac1f9e04ed902702e9878208b336edc9d6fddc8a48387349bab3666 \
    crate://crates.io/flexi_logger/0.27.4;sha256sum=469e584c031833564840fb0cdbce99bdfe946fd45480a188545e73a76f45461c;flexi_logger-0.27.4.sha256sum=469e584c031833564840fb0cdbce99bdfe946fd45480a188545e73a76f45461c \
    crate://crates.io/fnv/1.0.7;sha256sum=3f9eec918d3f24069decb9af1554cad7c880e2da24a9afd88aca000531ab82c1;fnv-1.0.7.sha256sum=3f9eec918d3f24069decb9af1554cad7c880e2da24a9afd88aca000531ab82c1 \
    crate://crates.io/foreign-types-shared/0.1.1;sha256sum=00b0228411908ca8685dba7fc2cdd70ec9990a6e753e89b6ac91a84c40fbaf4b;foreign-types-shared-0.1.1.sha256sum=00b0228411908ca8685dba7fc2cdd70ec9990a6e753e89b6ac91a84c40fbaf4b \
    crate://crates.io/foreign-types/0.3.2;sha256sum=f6f339eb8adc052cd2ca78910fda869aefa38d22d5cb648e6485e4d3fc06f3b1;foreign-types-0.3.2.sha256sum=f6f339eb8adc052cd2ca78910fda869aefa38d22d5cb648e6485e4d3fc06f3b1 \
    crate://crates.io/form_urlencoded/1.2.1;sha256sum=e13624c2627564efccf4934284bdd98cbaa14e79b0b5a141218e507b3a823456;form_urlencoded-1.2.1.sha256sum=e13624c2627564efccf4934284bdd98cbaa14e79b0b5a141218e507b3a823456 \
    crate://crates.io/fs_extra/1.2.0;sha256sum=2022715d62ab30faffd124d40b76f4134a550a87792276512b18d63272333394;fs_extra-1.2.0.sha256sum=2022715d62ab30faffd124d40b76f4134a550a87792276512b18d63272333394 \
    crate://crates.io/ftp/3.0.1;sha256sum=542951aad0071952c27409e3bd7cb62d1a3ad419c4e7314106bf994e0083ad5d;ftp-3.0.1.sha256sum=542951aad0071952c27409e3bd7cb62d1a3ad419c4e7314106bf994e0083ad5d \
    crate://crates.io/futures-core/0.3.30;sha256sum=dfc6580bb841c5a68e9ef15c77ccc837b40a7504914d52e47b8b0e9bbda25a1d;futures-core-0.3.30.sha256sum=dfc6580bb841c5a68e9ef15c77ccc837b40a7504914d52e47b8b0e9bbda25a1d \
    crate://crates.io/futures-io/0.3.30;sha256sum=a44623e20b9681a318efdd71c299b6b222ed6f231972bfe2f224ebad6311f0c1;futures-io-0.3.30.sha256sum=a44623e20b9681a318efdd71c299b6b222ed6f231972bfe2f224ebad6311f0c1 \
    crate://crates.io/futures-lite/1.13.0;sha256sum=49a9d51ce47660b1e808d3c990b4709f2f415d928835a17dfd16991515c46bce;futures-lite-1.13.0.sha256sum=49a9d51ce47660b1e808d3c990b4709f2f415d928835a17dfd16991515c46bce \
    crate://crates.io/futures-lite/2.3.0;sha256sum=52527eb5074e35e9339c6b4e8d12600c7128b68fb25dcb9fa9dec18f7c25f3a5;futures-lite-2.3.0.sha256sum=52527eb5074e35e9339c6b4e8d12600c7128b68fb25dcb9fa9dec18f7c25f3a5 \
    crate://crates.io/futures-sink/0.3.30;sha256sum=9fb8e00e87438d937621c1c6269e53f536c14d3fbd6a042bb24879e57d474fb5;futures-sink-0.3.30.sha256sum=9fb8e00e87438d937621c1c6269e53f536c14d3fbd6a042bb24879e57d474fb5 \
    crate://crates.io/futures-task/0.3.30;sha256sum=38d84fa142264698cdce1a9f9172cf383a0c82de1bddcf3092901442c4097004;futures-task-0.3.30.sha256sum=38d84fa142264698cdce1a9f9172cf383a0c82de1bddcf3092901442c4097004 \
    crate://crates.io/futures-util/0.3.30;sha256sum=3d6401deb83407ab3da39eba7e33987a73c3df0c82b4bb5813ee871c19c41d48;futures-util-0.3.30.sha256sum=3d6401deb83407ab3da39eba7e33987a73c3df0c82b4bb5813ee871c19c41d48 \
    crate://crates.io/generic-array/0.14.7;sha256sum=85649ca51fd72272d7821adaf274ad91c288277713d9c18820d8499a7ff69e9a;generic-array-0.14.7.sha256sum=85649ca51fd72272d7821adaf274ad91c288277713d9c18820d8499a7ff69e9a \
    crate://crates.io/getrandom/0.2.15;sha256sum=c4567c8db10ae91089c99af84c68c38da3ec2f087c3f82960bcdbf3656b6f4d7;getrandom-0.2.15.sha256sum=c4567c8db10ae91089c99af84c68c38da3ec2f087c3f82960bcdbf3656b6f4d7 \
    crate://crates.io/glob/0.3.1;sha256sum=d2fabcfbdc87f4758337ca535fb41a6d701b65693ce38287d856d1674551ec9b;glob-0.3.1.sha256sum=d2fabcfbdc87f4758337ca535fb41a6d701b65693ce38287d856d1674551ec9b \
    crate://crates.io/half/1.8.3;sha256sum=1b43ede17f21864e81be2fa654110bf1e793774238d86ef8555c37e6519c0403;half-1.8.3.sha256sum=1b43ede17f21864e81be2fa654110bf1e793774238d86ef8555c37e6519c0403 \
    crate://crates.io/hashbrown/0.12.3;sha256sum=8a9ee70c43aaf417c914396645a0fa852624801b24ebb7ae78fe8272889ac888;hashbrown-0.12.3.sha256sum=8a9ee70c43aaf417c914396645a0fa852624801b24ebb7ae78fe8272889ac888 \
    crate://crates.io/hashbrown/0.14.5;sha256sum=e5274423e17b7c9fc20b6e7e208532f9b19825d82dfd615708b70edd83df41f1;hashbrown-0.14.5.sha256sum=e5274423e17b7c9fc20b6e7e208532f9b19825d82dfd615708b70edd83df41f1 \
    crate://crates.io/hermit-abi/0.1.19;sha256sum=62b467343b94ba476dcb2500d242dadbb39557df889310ac77c5d99100aaac33;hermit-abi-0.1.19.sha256sum=62b467343b94ba476dcb2500d242dadbb39557df889310ac77c5d99100aaac33 \
    crate://crates.io/hermit-abi/0.3.9;sha256sum=d231dfb89cfffdbc30e7fc41579ed6066ad03abda9e567ccafae602b97ec5024;hermit-abi-0.3.9.sha256sum=d231dfb89cfffdbc30e7fc41579ed6066ad03abda9e567ccafae602b97ec5024 \
    crate://crates.io/hermit-abi/0.4.0;sha256sum=fbf6a919d6cf397374f7dfeeea91d974c7c0a7221d0d0f4f20d859d329e53fcc;hermit-abi-0.4.0.sha256sum=fbf6a919d6cf397374f7dfeeea91d974c7c0a7221d0d0f4f20d859d329e53fcc \
    crate://crates.io/hex/0.4.3;sha256sum=7f24254aa9a54b5c858eaee2f5bccdb46aaf0e486a595ed5fd8f86ba55232a70;hex-0.4.3.sha256sum=7f24254aa9a54b5c858eaee2f5bccdb46aaf0e486a595ed5fd8f86ba55232a70 \
    crate://crates.io/http/1.1.0;sha256sum=21b9ddb458710bc376481b842f5da65cdf31522de232c1ca8146abce2a358258;http-1.1.0.sha256sum=21b9ddb458710bc376481b842f5da65cdf31522de232c1ca8146abce2a358258 \
    crate://crates.io/httparse/1.9.4;sha256sum=0fcc0b4a115bf80b728eb8ea024ad5bd707b615bfed49e0665b6e0f86fd082d9;httparse-1.9.4.sha256sum=0fcc0b4a115bf80b728eb8ea024ad5bd707b615bfed49e0665b6e0f86fd082d9 \
    crate://crates.io/iana-time-zone-haiku/0.1.2;sha256sum=f31827a206f56af32e590ba56d5d2d085f558508192593743f16b2306495269f;iana-time-zone-haiku-0.1.2.sha256sum=f31827a206f56af32e590ba56d5d2d085f558508192593743f16b2306495269f \
    crate://crates.io/iana-time-zone/0.1.60;sha256sum=e7ffbb5a1b541ea2561f8c41c087286cc091e21e556a4f09a8f6cbf17b69b141;iana-time-zone-0.1.60.sha256sum=e7ffbb5a1b541ea2561f8c41c087286cc091e21e556a4f09a8f6cbf17b69b141 \
    crate://crates.io/ident_case/1.0.1;sha256sum=b9e0384b61958566e926dc50660321d12159025e767c18e043daf26b70104c39;ident_case-1.0.1.sha256sum=b9e0384b61958566e926dc50660321d12159025e767c18e043daf26b70104c39 \
    crate://crates.io/idna/0.5.0;sha256sum=634d9b1461af396cad843f47fdba5597a4f9e6ddd4bfb6ff5d85028c25cb12f6;idna-0.5.0.sha256sum=634d9b1461af396cad843f47fdba5597a4f9e6ddd4bfb6ff5d85028c25cb12f6 \
    crate://crates.io/indexmap/1.9.3;sha256sum=bd070e393353796e801d209ad339e89596eb4c8d430d18ede6a1cced8fafbd99;indexmap-1.9.3.sha256sum=bd070e393353796e801d209ad339e89596eb4c8d430d18ede6a1cced8fafbd99 \
    crate://crates.io/indexmap/2.4.0;sha256sum=93ead53efc7ea8ed3cfb0c79fc8023fbb782a5432b52830b6518941cebe6505c;indexmap-2.4.0.sha256sum=93ead53efc7ea8ed3cfb0c79fc8023fbb782a5432b52830b6518941cebe6505c \
    crate://crates.io/instant/0.1.13;sha256sum=e0242819d153cba4b4b05a5a8f2a7e9bbf97b6055b2a002b395c96b5ff3c0222;instant-0.1.13.sha256sum=e0242819d153cba4b4b05a5a8f2a7e9bbf97b6055b2a002b395c96b5ff3c0222 \
    crate://crates.io/io-lifetimes/1.0.11;sha256sum=eae7b9aee968036d54dce06cebaefd919e4472e753296daccd6d344e3e2df0c2;io-lifetimes-1.0.11.sha256sum=eae7b9aee968036d54dce06cebaefd919e4472e753296daccd6d344e3e2df0c2 \
    crate://crates.io/is-terminal/0.4.13;sha256sum=261f68e344040fbd0edea105bef17c66edf46f984ddb1115b775ce31be948f4b;is-terminal-0.4.13.sha256sum=261f68e344040fbd0edea105bef17c66edf46f984ddb1115b775ce31be948f4b \
    crate://crates.io/itertools/0.10.5;sha256sum=b0fd2260e829bddf4cb6ea802289de2f86d6a7a690192fbe91b3f46e0f2c8473;itertools-0.10.5.sha256sum=b0fd2260e829bddf4cb6ea802289de2f86d6a7a690192fbe91b3f46e0f2c8473 \
    crate://crates.io/itertools/0.12.1;sha256sum=ba291022dbbd398a455acf126c1e341954079855bc60dfdda641363bd6922569;itertools-0.12.1.sha256sum=ba291022dbbd398a455acf126c1e341954079855bc60dfdda641363bd6922569 \
    crate://crates.io/itoa/1.0.11;sha256sum=49f1f14873335454500d59611f1cf4a4b0f786f9ac11f4312a78e4cf2566695b;itoa-1.0.11.sha256sum=49f1f14873335454500d59611f1cf4a4b0f786f9ac11f4312a78e4cf2566695b \
    crate://crates.io/jack-sys/0.2.3;sha256sum=7b91f2d2d10bc2bab38f4dfa4bc77123a988828af39dd3f30dd9db14d44f2cc1;jack-sys-0.2.3.sha256sum=7b91f2d2d10bc2bab38f4dfa4bc77123a988828af39dd3f30dd9db14d44f2cc1 \
    crate://crates.io/jack/0.8.4;sha256sum=5d2ac12f11bb369f3c50d24dbb9fdb00dc987434c9dd622a12c13f618106e153;jack-0.8.4.sha256sum=5d2ac12f11bb369f3c50d24dbb9fdb00dc987434c9dd622a12c13f618106e153 \
    crate://crates.io/jni-sys/0.3.0;sha256sum=8eaf4bc02d17cbdd7ff4c7438cafcdf7fb9a4613313ad11b4f8fefe7d3fa0130;jni-sys-0.3.0.sha256sum=8eaf4bc02d17cbdd7ff4c7438cafcdf7fb9a4613313ad11b4f8fefe7d3fa0130 \
    crate://crates.io/jni/0.19.0;sha256sum=c6df18c2e3db7e453d3c6ac5b3e9d5182664d28788126d39b91f2d1e22b017ec;jni-0.19.0.sha256sum=c6df18c2e3db7e453d3c6ac5b3e9d5182664d28788126d39b91f2d1e22b017ec \
    crate://crates.io/jobserver/0.1.32;sha256sum=48d1dbcbbeb6a7fec7e059840aa538bd62aaccf972c7346c4d9d2059312853d0;jobserver-0.1.32.sha256sum=48d1dbcbbeb6a7fec7e059840aa538bd62aaccf972c7346c4d9d2059312853d0 \
    crate://crates.io/js-sys/0.3.70;sha256sum=1868808506b929d7b0cfa8f75951347aa71bb21144b7791bae35d9bccfcfe37a;js-sys-0.3.70.sha256sum=1868808506b929d7b0cfa8f75951347aa71bb21144b7791bae35d9bccfcfe37a \
    crate://crates.io/kernel32-sys/0.2.2;sha256sum=7507624b29483431c0ba2d82aece8ca6cdba9382bff4ddd0f7490560c056098d;kernel32-sys-0.2.2.sha256sum=7507624b29483431c0ba2d82aece8ca6cdba9382bff4ddd0f7490560c056098d \
    crate://crates.io/lazy_static/0.1.16;sha256sum=cf186d1a8aa5f5bee5fd662bc9c1b949e0259e1bcc379d1f006847b0080c7417;lazy_static-0.1.16.sha256sum=cf186d1a8aa5f5bee5fd662bc9c1b949e0259e1bcc379d1f006847b0080c7417 \
    crate://crates.io/lazy_static/1.5.0;sha256sum=bbd2bcb4c963f2ddae06a2efc7e9f3591312473c50c6685e1f298068316e66fe;lazy_static-1.5.0.sha256sum=bbd2bcb4c963f2ddae06a2efc7e9f3591312473c50c6685e1f298068316e66fe \
    crate://crates.io/lazycell/1.3.0;sha256sum=830d08ce1d1d941e6b30645f1a0eb5643013d835ce3779a5fc208261dbe10f55;lazycell-1.3.0.sha256sum=830d08ce1d1d941e6b30645f1a0eb5643013d835ce3779a5fc208261dbe10f55 \
    crate://crates.io/libc/0.2.158;sha256sum=d8adc4bb1803a324070e64a98ae98f38934d91957a99cfb3a43dcbc01bc56439;libc-0.2.158.sha256sum=d8adc4bb1803a324070e64a98ae98f38934d91957a99cfb3a43dcbc01bc56439 \
    crate://crates.io/libloading/0.6.7;sha256sum=351a32417a12d5f7e82c368a66781e307834dae04c6ce0cd4456d52989229883;libloading-0.6.7.sha256sum=351a32417a12d5f7e82c368a66781e307834dae04c6ce0cd4456d52989229883 \
    crate://crates.io/libloading/0.8.5;sha256sum=4979f22fdb869068da03c9f7528f8297c6fd2606bc3a4affe42e6a823fdb8da4;libloading-0.8.5.sha256sum=4979f22fdb869068da03c9f7528f8297c6fd2606bc3a4affe42e6a823fdb8da4 \
    crate://crates.io/libm/0.2.8;sha256sum=4ec2a862134d2a7d32d7983ddcdd1c4923530833c9f2ea1a44fc5fa473989058;libm-0.2.8.sha256sum=4ec2a862134d2a7d32d7983ddcdd1c4923530833c9f2ea1a44fc5fa473989058 \
    crate://crates.io/libpulse-binding/2.28.1;sha256sum=ed3557a2dfc380c8f061189a01c6ae7348354e0c9886038dc6c171219c08eaff;libpulse-binding-2.28.1.sha256sum=ed3557a2dfc380c8f061189a01c6ae7348354e0c9886038dc6c171219c08eaff \
    crate://crates.io/libpulse-simple-binding/2.28.1;sha256sum=05fd6b68f33f6a251265e6ed1212dc3107caad7c5c6fdcd847b2e65ef58c308d;libpulse-simple-binding-2.28.1.sha256sum=05fd6b68f33f6a251265e6ed1212dc3107caad7c5c6fdcd847b2e65ef58c308d \
    crate://crates.io/libpulse-simple-sys/1.21.1;sha256sum=ea6613b4199d8b9f0edcfb623e020cb17bbd0bee8dd21f3c7cc938de561c4152;libpulse-simple-sys-1.21.1.sha256sum=ea6613b4199d8b9f0edcfb623e020cb17bbd0bee8dd21f3c7cc938de561c4152 \
    crate://crates.io/libpulse-sys/1.21.0;sha256sum=bc19e110fbf42c17260d30f6d3dc545f58491c7830d38ecb9aaca96e26067a9b;libpulse-sys-1.21.0.sha256sum=bc19e110fbf42c17260d30f6d3dc545f58491c7830d38ecb9aaca96e26067a9b \
    crate://crates.io/linked-hash-map/0.5.6;sha256sum=0717cef1bc8b636c6e1c1bbdefc09e6322da8a9321966e8928ef80d20f7f770f;linked-hash-map-0.5.6.sha256sum=0717cef1bc8b636c6e1c1bbdefc09e6322da8a9321966e8928ef80d20f7f770f \
    crate://crates.io/linux-raw-sys/0.3.8;sha256sum=ef53942eb7bf7ff43a617b3e2c1c4a5ecf5944a7c1bc12d7ee39bbb15e5c1519;linux-raw-sys-0.3.8.sha256sum=ef53942eb7bf7ff43a617b3e2c1c4a5ecf5944a7c1bc12d7ee39bbb15e5c1519 \
    crate://crates.io/linux-raw-sys/0.4.14;sha256sum=78b3ae25bc7c8c38cec158d1f2757ee79e9b3740fbc7ccf0e59e4b08d793fa89;linux-raw-sys-0.4.14.sha256sum=78b3ae25bc7c8c38cec158d1f2757ee79e9b3740fbc7ccf0e59e4b08d793fa89 \
    crate://crates.io/lock_api/0.4.12;sha256sum=07af8b9cdd281b7915f413fa73f29ebd5d55d0d3f0155584dade1ff18cea1b17;lock_api-0.4.12.sha256sum=07af8b9cdd281b7915f413fa73f29ebd5d55d0d3f0155584dade1ff18cea1b17 \
    crate://crates.io/log/0.4.22;sha256sum=a7a70ba024b9dc04c27ea2f0c0548feb474ec5c54bba33a7f72f873a39d07b24;log-0.4.22.sha256sum=a7a70ba024b9dc04c27ea2f0c0548feb474ec5c54bba33a7f72f873a39d07b24 \
    crate://crates.io/mach/0.3.2;sha256sum=b823e83b2affd8f40a9ee8c29dbc56404c1e34cd2710921f2801e2cf29527afa;mach-0.3.2.sha256sum=b823e83b2affd8f40a9ee8c29dbc56404c1e34cd2710921f2801e2cf29527afa \
    crate://crates.io/matrixmultiply/0.2.4;sha256sum=916806ba0031cd542105d916a97c8572e1fa6dd79c9c51e7eb43a09ec2dd84c1;matrixmultiply-0.2.4.sha256sum=916806ba0031cd542105d916a97c8572e1fa6dd79c9c51e7eb43a09ec2dd84c1 \
    crate://crates.io/memchr/0.1.11;sha256sum=d8b629fb514376c675b98c1421e80b151d3817ac42d7c667717d282761418d20;memchr-0.1.11.sha256sum=d8b629fb514376c675b98c1421e80b151d3817ac42d7c667717d282761418d20 \
    crate://crates.io/memchr/2.7.4;sha256sum=78ca9ab1a0babb1e7d5695e3530886289c18cf2f87ec19a575a0abdce112e3a3;memchr-2.7.4.sha256sum=78ca9ab1a0babb1e7d5695e3530886289c18cf2f87ec19a575a0abdce112e3a3 \
    crate://crates.io/memoffset/0.6.5;sha256sum=5aa361d4faea93603064a027415f07bd8e1d5c88c9fbf68bf56a285428fd79ce;memoffset-0.6.5.sha256sum=5aa361d4faea93603064a027415f07bd8e1d5c88c9fbf68bf56a285428fd79ce \
    crate://crates.io/memoffset/0.7.1;sha256sum=5de893c32cde5f383baa4c04c5d6dbdd735cfd4a794b0debdb2bb1b421da5ff4;memoffset-0.7.1.sha256sum=5de893c32cde5f383baa4c04c5d6dbdd735cfd4a794b0debdb2bb1b421da5ff4 \
    crate://crates.io/memoffset/0.9.1;sha256sum=488016bfae457b036d996092f6cb448677611ce4449e970ceaf42695203f218a;memoffset-0.9.1.sha256sum=488016bfae457b036d996092f6cb448677611ce4449e970ceaf42695203f218a \
    crate://crates.io/minimal-lexical/0.2.1;sha256sum=68354c5c6bd36d73ff3feceb05efa59b6acb7626617f4962be322a825e61f79a;minimal-lexical-0.2.1.sha256sum=68354c5c6bd36d73ff3feceb05efa59b6acb7626617f4962be322a825e61f79a \
    crate://crates.io/miniz_oxide/0.8.0;sha256sum=e2d80299ef12ff69b16a84bb182e3b9df68b5a91574d3d4fa6e41b65deec4df1;miniz_oxide-0.8.0.sha256sum=e2d80299ef12ff69b16a84bb182e3b9df68b5a91574d3d4fa6e41b65deec4df1 \
    crate://crates.io/native-tls/0.2.12;sha256sum=a8614eb2c83d59d1c8cc974dd3f920198647674a0a035e1af1fa58707e317466;native-tls-0.2.12.sha256sum=a8614eb2c83d59d1c8cc974dd3f920198647674a0a035e1af1fa58707e317466 \
    crate://crates.io/ndarray/0.14.0;sha256sum=6c0d5c9540a691d153064dc47a4db2504587a75eae07bf1d73f7a596ebc73c04;ndarray-0.14.0.sha256sum=6c0d5c9540a691d153064dc47a4db2504587a75eae07bf1d73f7a596ebc73c04 \
    crate://crates.io/ndk-context/0.1.1;sha256sum=27b02d87554356db9e9a873add8782d4ea6e3e58ea071a9adb9a2e8ddb884a8b;ndk-context-0.1.1.sha256sum=27b02d87554356db9e9a873add8782d4ea6e3e58ea071a9adb9a2e8ddb884a8b \
    crate://crates.io/ndk-glue/0.6.2;sha256sum=0d0c4a7b83860226e6b4183edac21851f05d5a51756e97a1144b7f5a6b63e65f;ndk-glue-0.6.2.sha256sum=0d0c4a7b83860226e6b4183edac21851f05d5a51756e97a1144b7f5a6b63e65f \
    crate://crates.io/ndk-macro/0.3.0;sha256sum=0df7ac00c4672f9d5aece54ee3347520b7e20f158656c7db2e6de01902eb7a6c;ndk-macro-0.3.0.sha256sum=0df7ac00c4672f9d5aece54ee3347520b7e20f158656c7db2e6de01902eb7a6c \
    crate://crates.io/ndk-sys/0.3.0;sha256sum=6e5a6ae77c8ee183dcbbba6150e2e6b9f3f4196a7666c02a715a95692ec1fa97;ndk-sys-0.3.0.sha256sum=6e5a6ae77c8ee183dcbbba6150e2e6b9f3f4196a7666c02a715a95692ec1fa97 \
    crate://crates.io/ndk/0.6.0;sha256sum=2032c77e030ddee34a6787a64166008da93f6a352b629261d0fee232b8742dd4;ndk-0.6.0.sha256sum=2032c77e030ddee34a6787a64166008da93f6a352b629261d0fee232b8742dd4 \
    crate://crates.io/nix/0.23.2;sha256sum=8f3790c00a0150112de0f4cd161e3d7fc4b2d8a5542ffc35f099a2562aecb35c;nix-0.23.2.sha256sum=8f3790c00a0150112de0f4cd161e3d7fc4b2d8a5542ffc35f099a2562aecb35c \
    crate://crates.io/nix/0.26.4;sha256sum=598beaf3cc6fdd9a5dfb1630c2800c7acd31df7aaf0f565796fba2b53ca1af1b;nix-0.26.4.sha256sum=598beaf3cc6fdd9a5dfb1630c2800c7acd31df7aaf0f565796fba2b53ca1af1b \
    crate://crates.io/nom/7.1.3;sha256sum=d273983c5a657a70a3e8f2a01329822f3b8c8172b73826411a55751e404a0a4a;nom-7.1.3.sha256sum=d273983c5a657a70a3e8f2a01329822f3b8c8172b73826411a55751e404a0a4a \
    crate://crates.io/nu-ansi-term/0.49.0;sha256sum=c073d3c1930d0751774acf49e66653acecb416c3a54c6ec095a9b11caddb5a68;nu-ansi-term-0.49.0.sha256sum=c073d3c1930d0751774acf49e66653acecb416c3a54c6ec095a9b11caddb5a68 \
    crate://crates.io/num-complex/0.3.1;sha256sum=747d632c0c558b87dbabbe6a82f3b4ae03720d0646ac5b7b4dae89394be5f2c5;num-complex-0.3.1.sha256sum=747d632c0c558b87dbabbe6a82f3b4ae03720d0646ac5b7b4dae89394be5f2c5 \
    crate://crates.io/num-complex/0.4.6;sha256sum=73f88a1307638156682bada9d7604135552957b7818057dcef22705b4d509495;num-complex-0.4.6.sha256sum=73f88a1307638156682bada9d7604135552957b7818057dcef22705b4d509495 \
    crate://crates.io/num-derive/0.3.3;sha256sum=876a53fff98e03a936a674b29568b0e605f06b29372c2489ff4de23f1949743d;num-derive-0.3.3.sha256sum=876a53fff98e03a936a674b29568b0e605f06b29372c2489ff4de23f1949743d \
    crate://crates.io/num-integer/0.1.46;sha256sum=7969661fd2958a5cb096e56c8e1ad0444ac2bbcd0061bd28660485a44879858f;num-integer-0.1.46.sha256sum=7969661fd2958a5cb096e56c8e1ad0444ac2bbcd0061bd28660485a44879858f \
    crate://crates.io/num-iter/0.1.45;sha256sum=1429034a0490724d0075ebb2bc9e875d6503c3cf69e235a8941aa757d83ef5bf;num-iter-0.1.45.sha256sum=1429034a0490724d0075ebb2bc9e875d6503c3cf69e235a8941aa757d83ef5bf \
    crate://crates.io/num-traits/0.2.19;sha256sum=071dfc062690e90b734c0b2273ce72ad0ffa95f0c74596bc250dcfd960262841;num-traits-0.2.19.sha256sum=071dfc062690e90b734c0b2273ce72ad0ffa95f0c74596bc250dcfd960262841 \
    crate://crates.io/num/0.1.42;sha256sum=4703ad64153382334aa8db57c637364c322d3372e097840c72000dabdcf6156e;num-0.1.42.sha256sum=4703ad64153382334aa8db57c637364c322d3372e097840c72000dabdcf6156e \
    crate://crates.io/num_enum/0.5.11;sha256sum=1f646caf906c20226733ed5b1374287eb97e3c2a5c227ce668c1f2ce20ae57c9;num_enum-0.5.11.sha256sum=1f646caf906c20226733ed5b1374287eb97e3c2a5c227ce668c1f2ce20ae57c9 \
    crate://crates.io/num_enum_derive/0.5.11;sha256sum=dcbff9bc912032c62bf65ef1d5aea88983b420f4f839db1e9b0c281a25c9c799;num_enum_derive-0.5.11.sha256sum=dcbff9bc912032c62bf65ef1d5aea88983b420f4f839db1e9b0c281a25c9c799 \
    crate://crates.io/oboe-sys/0.4.5;sha256sum=3370abb7372ed744232c12954d920d1a40f1c4686de9e79e800021ef492294bd;oboe-sys-0.4.5.sha256sum=3370abb7372ed744232c12954d920d1a40f1c4686de9e79e800021ef492294bd \
    crate://crates.io/oboe/0.4.6;sha256sum=27f63c358b4fa0fbcfefd7c8be5cfc39c08ce2389f5325687e7762a48d30a5c1;oboe-0.4.6.sha256sum=27f63c358b4fa0fbcfefd7c8be5cfc39c08ce2389f5325687e7762a48d30a5c1 \
    crate://crates.io/once_cell/1.19.0;sha256sum=3fdb12b2476b595f9358c5161aa467c2438859caa136dec86c26fdd2efe17b92;once_cell-1.19.0.sha256sum=3fdb12b2476b595f9358c5161aa467c2438859caa136dec86c26fdd2efe17b92 \
    crate://crates.io/oorandom/11.1.4;sha256sum=b410bbe7e14ab526a0e86877eb47c6996a2bd7746f027ba551028c925390e4e9;oorandom-11.1.4.sha256sum=b410bbe7e14ab526a0e86877eb47c6996a2bd7746f027ba551028c925390e4e9 \
    crate://crates.io/openssl-macros/0.1.1;sha256sum=a948666b637a0f465e8564c73e89d4dde00d72d4d473cc972f390fc3dcee7d9c;openssl-macros-0.1.1.sha256sum=a948666b637a0f465e8564c73e89d4dde00d72d4d473cc972f390fc3dcee7d9c \
    crate://crates.io/openssl-probe/0.1.5;sha256sum=ff011a302c396a5197692431fc1948019154afc178baf7d8e37367442a4601cf;openssl-probe-0.1.5.sha256sum=ff011a302c396a5197692431fc1948019154afc178baf7d8e37367442a4601cf \
    crate://crates.io/openssl-sys/0.9.103;sha256sum=7f9e8deee91df40a943c71b917e5874b951d32a802526c85721ce3b776c929d6;openssl-sys-0.9.103.sha256sum=7f9e8deee91df40a943c71b917e5874b951d32a802526c85721ce3b776c929d6 \
    crate://crates.io/openssl/0.10.66;sha256sum=9529f4786b70a3e8c61e11179af17ab6188ad8d0ded78c5529441ed39d4bd9c1;openssl-0.10.66.sha256sum=9529f4786b70a3e8c61e11179af17ab6188ad8d0ded78c5529441ed39d4bd9c1 \
    crate://crates.io/ordered-stream/0.2.0;sha256sum=9aa2b01e1d916879f73a53d01d1d6cee68adbb31d6d9177a8cfce093cced1d50;ordered-stream-0.2.0.sha256sum=9aa2b01e1d916879f73a53d01d1d6cee68adbb31d6d9177a8cfce093cced1d50 \
    crate://crates.io/parking/2.2.0;sha256sum=bb813b8af86854136c6922af0598d719255ecb2179515e6e7730d468f05c9cae;parking-2.2.0.sha256sum=bb813b8af86854136c6922af0598d719255ecb2179515e6e7730d468f05c9cae \
    crate://crates.io/parking_lot/0.11.2;sha256sum=7d17b78036a60663b797adeaee46f5c9dfebb86948d1255007a1d6be0271ff99;parking_lot-0.11.2.sha256sum=7d17b78036a60663b797adeaee46f5c9dfebb86948d1255007a1d6be0271ff99 \
    crate://crates.io/parking_lot/0.12.3;sha256sum=f1bf18183cf54e8d6059647fc3063646a1801cf30896933ec2311622cc4b9a27;parking_lot-0.12.3.sha256sum=f1bf18183cf54e8d6059647fc3063646a1801cf30896933ec2311622cc4b9a27 \
    crate://crates.io/parking_lot_core/0.8.6;sha256sum=60a2cfe6f0ad2bfc16aefa463b497d5c7a5ecd44a23efa72aa342d90177356dc;parking_lot_core-0.8.6.sha256sum=60a2cfe6f0ad2bfc16aefa463b497d5c7a5ecd44a23efa72aa342d90177356dc \
    crate://crates.io/parking_lot_core/0.9.10;sha256sum=1e401f977ab385c9e4e3ab30627d6f26d00e2c73eef317493c4ec6d468726cf8;parking_lot_core-0.9.10.sha256sum=1e401f977ab385c9e4e3ab30627d6f26d00e2c73eef317493c4ec6d468726cf8 \
    crate://crates.io/percent-encoding/2.3.1;sha256sum=e3148f5046208a5d56bcfc03053e3ca6334e51da8dfb19b6cdc8b306fae3283e;percent-encoding-2.3.1.sha256sum=e3148f5046208a5d56bcfc03053e3ca6334e51da8dfb19b6cdc8b306fae3283e \
    crate://crates.io/pin-project-lite/0.2.14;sha256sum=bda66fc9667c18cb2758a2ac84d1167245054bcf85d5d1aaa6923f45801bdd02;pin-project-lite-0.2.14.sha256sum=bda66fc9667c18cb2758a2ac84d1167245054bcf85d5d1aaa6923f45801bdd02 \
    crate://crates.io/pin-utils/0.1.0;sha256sum=8b870d8c151b6f2fb93e84a13146138f05d02ed11c7e7c54f8826aaaf7c9f184;pin-utils-0.1.0.sha256sum=8b870d8c151b6f2fb93e84a13146138f05d02ed11c7e7c54f8826aaaf7c9f184 \
    crate://crates.io/piper/0.2.4;sha256sum=96c8c490f422ef9a4efd2cb5b42b76c8613d7e7dfc1caf667b8a3350a5acc066;piper-0.2.4.sha256sum=96c8c490f422ef9a4efd2cb5b42b76c8613d7e7dfc1caf667b8a3350a5acc066 \
    crate://crates.io/pkg-config/0.3.30;sha256sum=d231b230927b5e4ad203db57bbcbee2802f6bce620b1e4a9024a07d94e2907ec;pkg-config-0.3.30.sha256sum=d231b230927b5e4ad203db57bbcbee2802f6bce620b1e4a9024a07d94e2907ec \
    crate://crates.io/plotters-backend/0.3.6;sha256sum=414cec62c6634ae900ea1c56128dfe87cf63e7caece0852ec76aba307cebadb7;plotters-backend-0.3.6.sha256sum=414cec62c6634ae900ea1c56128dfe87cf63e7caece0852ec76aba307cebadb7 \
    crate://crates.io/plotters-svg/0.3.6;sha256sum=81b30686a7d9c3e010b84284bdd26a29f2138574f52f5eb6f794fc0ad924e705;plotters-svg-0.3.6.sha256sum=81b30686a7d9c3e010b84284bdd26a29f2138574f52f5eb6f794fc0ad924e705 \
    crate://crates.io/plotters/0.3.6;sha256sum=a15b6eccb8484002195a3e44fe65a4ce8e93a625797a063735536fd59cb01cf3;plotters-0.3.6.sha256sum=a15b6eccb8484002195a3e44fe65a4ce8e93a625797a063735536fd59cb01cf3 \
    crate://crates.io/polling/2.8.0;sha256sum=4b2d323e8ca7996b3e23126511a523f7e62924d93ecd5ae73b333815b0eb3dce;polling-2.8.0.sha256sum=4b2d323e8ca7996b3e23126511a523f7e62924d93ecd5ae73b333815b0eb3dce \
    crate://crates.io/polling/3.7.3;sha256sum=cc2790cd301dec6cd3b7a025e4815cf825724a51c98dccfe6a3e55f05ffb6511;polling-3.7.3.sha256sum=cc2790cd301dec6cd3b7a025e4815cf825724a51c98dccfe6a3e55f05ffb6511 \
    crate://crates.io/ppv-lite86/0.2.20;sha256sum=77957b295656769bb8ad2b6a6b09d897d94f05c41b069aede1fcdaa675eaea04;ppv-lite86-0.2.20.sha256sum=77957b295656769bb8ad2b6a6b09d897d94f05c41b069aede1fcdaa675eaea04 \
    crate://crates.io/primal-check/0.3.4;sha256sum=dc0d895b311e3af9902528fbb8f928688abbd95872819320517cc24ca6b2bd08;primal-check-0.3.4.sha256sum=dc0d895b311e3af9902528fbb8f928688abbd95872819320517cc24ca6b2bd08 \
    crate://crates.io/proc-macro-crate/1.3.1;sha256sum=7f4c021e1093a56626774e81216a4ce732a735e5bad4868a03f3ed65ca0c3919;proc-macro-crate-1.3.1.sha256sum=7f4c021e1093a56626774e81216a4ce732a735e5bad4868a03f3ed65ca0c3919 \
    crate://crates.io/proc-macro2/1.0.86;sha256sum=5e719e8df665df0d1c8fbfd238015744736151d4445ec0836b8e628aae103b77;proc-macro2-1.0.86.sha256sum=5e719e8df665df0d1c8fbfd238015744736151d4445ec0836b8e628aae103b77 \
    crate://crates.io/quote/1.0.37;sha256sum=b5b9d34b8991d19d98081b46eacdd8eb58c6f2b201139f7c5f643cc155a633af;quote-1.0.37.sha256sum=b5b9d34b8991d19d98081b46eacdd8eb58c6f2b201139f7c5f643cc155a633af \
    crate://crates.io/rand/0.8.5;sha256sum=34af8d1a0e25924bc5b7c43c079c942339d8f0a8b57c39049bef581b46327404;rand-0.8.5.sha256sum=34af8d1a0e25924bc5b7c43c079c942339d8f0a8b57c39049bef581b46327404 \
    crate://crates.io/rand_chacha/0.3.1;sha256sum=e6c10a63a0fa32252be49d21e7709d4d4baf8d231c2dbce1eaa8141b9b127d88;rand_chacha-0.3.1.sha256sum=e6c10a63a0fa32252be49d21e7709d4d4baf8d231c2dbce1eaa8141b9b127d88 \
    crate://crates.io/rand_core/0.6.4;sha256sum=ec0be4795e2f6a28069bec0b5ff3e2ac9bafc99e6a9a7dc3547996c5c816922c;rand_core-0.6.4.sha256sum=ec0be4795e2f6a28069bec0b5ff3e2ac9bafc99e6a9a7dc3547996c5c816922c \
    crate://crates.io/rand_distr/0.4.3;sha256sum=32cb0b9bc82b0a0876c2dd994a7e7a2683d3e7390ca40e6886785ef0c7e3ee31;rand_distr-0.4.3.sha256sum=32cb0b9bc82b0a0876c2dd994a7e7a2683d3e7390ca40e6886785ef0c7e3ee31 \
    crate://crates.io/rawpointer/0.2.1;sha256sum=60a357793950651c4ed0f3f52338f53b2f809f32d83a07f72909fa13e4c6c1e3;rawpointer-0.2.1.sha256sum=60a357793950651c4ed0f3f52338f53b2f809f32d83a07f72909fa13e4c6c1e3 \
    crate://crates.io/rawsample/0.2.0;sha256sum=ffb6c62a8f838420b4bb444ce954d99f827dd3bd5227ffb56b24e2298c5380d9;rawsample-0.2.0.sha256sum=ffb6c62a8f838420b4bb444ce954d99f827dd3bd5227ffb56b24e2298c5380d9 \
    crate://crates.io/rayon-core/1.12.1;sha256sum=1465873a3dfdaa8ae7cb14b4383657caab0b3e8a0aa9ae8e04b044854c8dfce2;rayon-core-1.12.1.sha256sum=1465873a3dfdaa8ae7cb14b4383657caab0b3e8a0aa9ae8e04b044854c8dfce2 \
    crate://crates.io/rayon/1.10.0;sha256sum=b418a60154510ca1a002a752ca9714984e21e4241e804d32555251faf8b78ffa;rayon-1.10.0.sha256sum=b418a60154510ca1a002a752ca9714984e21e4241e804d32555251faf8b78ffa \
    crate://crates.io/realfft/3.3.0;sha256sum=953d9f7e5cdd80963547b456251296efc2626ed4e3cbf36c869d9564e0220571;realfft-3.3.0.sha256sum=953d9f7e5cdd80963547b456251296efc2626ed4e3cbf36c869d9564e0220571 \
    crate://crates.io/redox_syscall/0.2.16;sha256sum=fb5a58c1855b4b6819d59012155603f0b22ad30cad752600aadfcb695265519a;redox_syscall-0.2.16.sha256sum=fb5a58c1855b4b6819d59012155603f0b22ad30cad752600aadfcb695265519a \
    crate://crates.io/redox_syscall/0.5.3;sha256sum=2a908a6e00f1fdd0dfd9c0eb08ce85126f6d8bbda50017e74bc4a4b7d4a926a4;redox_syscall-0.5.3.sha256sum=2a908a6e00f1fdd0dfd9c0eb08ce85126f6d8bbda50017e74bc4a4b7d4a926a4 \
    crate://crates.io/regex-automata/0.4.7;sha256sum=38caf58cc5ef2fed281f89292ef23f6365465ed9a41b7a7754eb4e26496c92df;regex-automata-0.4.7.sha256sum=38caf58cc5ef2fed281f89292ef23f6365465ed9a41b7a7754eb4e26496c92df \
    crate://crates.io/regex-syntax/0.3.9;sha256sum=f9ec002c35e86791825ed294b50008eea9ddfc8def4420124fbc6b08db834957;regex-syntax-0.3.9.sha256sum=f9ec002c35e86791825ed294b50008eea9ddfc8def4420124fbc6b08db834957 \
    crate://crates.io/regex-syntax/0.8.4;sha256sum=7a66a03ae7c801facd77a29370b4faec201768915ac14a721ba36f20bc9c209b;regex-syntax-0.8.4.sha256sum=7a66a03ae7c801facd77a29370b4faec201768915ac14a721ba36f20bc9c209b \
    crate://crates.io/regex/0.1.80;sha256sum=4fd4ace6a8cf7860714a2c2280d6c1f7e6a413486c13298bbc86fd3da019402f;regex-0.1.80.sha256sum=4fd4ace6a8cf7860714a2c2280d6c1f7e6a413486c13298bbc86fd3da019402f \
    crate://crates.io/regex/1.10.6;sha256sum=4219d74c6b67a3654a9fbebc4b419e22126d13d2f3c4a07ee0cb61ff79a79619;regex-1.10.6.sha256sum=4219d74c6b67a3654a9fbebc4b419e22126d13d2f3c4a07ee0cb61ff79a79619 \
    crate://crates.io/rubato/0.14.1;sha256sum=e6dd52e80cfc21894deadf554a5673002938ae4625f7a283e536f9cf7c17b0d5;rubato-0.14.1.sha256sum=e6dd52e80cfc21894deadf554a5673002938ae4625f7a283e536f9cf7c17b0d5 \
    crate://crates.io/rustc-hash/1.1.0;sha256sum=08d43f7aa6b08d49f382cde6a7982047c3426db949b1424bc4b7ec9ae12c6ce2;rustc-hash-1.1.0.sha256sum=08d43f7aa6b08d49f382cde6a7982047c3426db949b1424bc4b7ec9ae12c6ce2 \
    crate://crates.io/rustfft/6.2.0;sha256sum=43806561bc506d0c5d160643ad742e3161049ac01027b5e6d7524091fd401d86;rustfft-6.2.0.sha256sum=43806561bc506d0c5d160643ad742e3161049ac01027b5e6d7524091fd401d86 \
    crate://crates.io/rustix/0.37.27;sha256sum=fea8ca367a3a01fe35e6943c400addf443c0f57670e6ec51196f71a4b8762dd2;rustix-0.37.27.sha256sum=fea8ca367a3a01fe35e6943c400addf443c0f57670e6ec51196f71a4b8762dd2 \
    crate://crates.io/rustix/0.38.34;sha256sum=70dc5ec042f7a43c4a73241207cecc9873a06d45debb38b329f8541d85c2730f;rustix-0.38.34.sha256sum=70dc5ec042f7a43c4a73241207cecc9873a06d45debb38b329f8541d85c2730f \
    crate://crates.io/ryu/1.0.18;sha256sum=f3cb5ba0dc43242ce17de99c180e96db90b235b8a9fdc9543c96d2209116bd9f;ryu-1.0.18.sha256sum=f3cb5ba0dc43242ce17de99c180e96db90b235b8a9fdc9543c96d2209116bd9f \
    crate://crates.io/same-file/1.0.6;sha256sum=93fc1dc3aaa9bfed95e02e6eadabb4baf7e3078b0bd1b4d7b6b0b68378900502;same-file-1.0.6.sha256sum=93fc1dc3aaa9bfed95e02e6eadabb4baf7e3078b0bd1b4d7b6b0b68378900502 \
    crate://crates.io/schannel/0.1.23;sha256sum=fbc91545643bcf3a0bbb6569265615222618bdf33ce4ffbbd13c4bbd4c093534;schannel-0.1.23.sha256sum=fbc91545643bcf3a0bbb6569265615222618bdf33ce4ffbbd13c4bbd4c093534 \
    crate://crates.io/scopeguard/1.2.0;sha256sum=94143f37725109f92c262ed2cf5e59bce7498c01bcc1502d7b9afe439a4e9f49;scopeguard-1.2.0.sha256sum=94143f37725109f92c262ed2cf5e59bce7498c01bcc1502d7b9afe439a4e9f49 \
    crate://crates.io/security-framework-sys/2.11.1;sha256sum=75da29fe9b9b08fe9d6b22b5b4bcbc75d8db3aa31e639aa56bb62e9d46bfceaf;security-framework-sys-2.11.1.sha256sum=75da29fe9b9b08fe9d6b22b5b4bcbc75d8db3aa31e639aa56bb62e9d46bfceaf \
    crate://crates.io/security-framework/2.11.1;sha256sum=897b2245f0b511c87893af39b033e5ca9cce68824c4d7e7630b5a1d339658d02;security-framework-2.11.1.sha256sum=897b2245f0b511c87893af39b033e5ca9cce68824c4d7e7630b5a1d339658d02 \
    crate://crates.io/serde/1.0.209;sha256sum=99fce0ffe7310761ca6bf9faf5115afbc19688edd00171d81b1bb1b116c63e09;serde-1.0.209.sha256sum=99fce0ffe7310761ca6bf9faf5115afbc19688edd00171d81b1bb1b116c63e09 \
    crate://crates.io/serde_cbor/0.11.2;sha256sum=2bef2ebfde456fb76bbcf9f59315333decc4fda0b2b44b420243c11e0f5ec1f5;serde_cbor-0.11.2.sha256sum=2bef2ebfde456fb76bbcf9f59315333decc4fda0b2b44b420243c11e0f5ec1f5 \
    crate://crates.io/serde_derive/1.0.209;sha256sum=a5831b979fd7b5439637af1752d535ff49f4860c0f341d1baeb6faf0f4242170;serde_derive-1.0.209.sha256sum=a5831b979fd7b5439637af1752d535ff49f4860c0f341d1baeb6faf0f4242170 \
    crate://crates.io/serde_json/1.0.127;sha256sum=8043c06d9f82bd7271361ed64f415fe5e12a77fdb52e573e7f06a516dea329ad;serde_json-1.0.127.sha256sum=8043c06d9f82bd7271361ed64f415fe5e12a77fdb52e573e7f06a516dea329ad \
    crate://crates.io/serde_repr/0.1.19;sha256sum=6c64451ba24fc7a6a2d60fc75dd9c83c90903b19028d4eff35e88fc1e86564e9;serde_repr-0.1.19.sha256sum=6c64451ba24fc7a6a2d60fc75dd9c83c90903b19028d4eff35e88fc1e86564e9 \
    crate://crates.io/serde_with/1.14.0;sha256sum=678b5a069e50bf00ecd22d0cd8ddf7c236f68581b03db652061ed5eb13a312ff;serde_with-1.14.0.sha256sum=678b5a069e50bf00ecd22d0cd8ddf7c236f68581b03db652061ed5eb13a312ff \
    crate://crates.io/serde_with_macros/1.5.2;sha256sum=e182d6ec6f05393cc0e5ed1bf81ad6db3a8feedf8ee515ecdd369809bcce8082;serde_with_macros-1.5.2.sha256sum=e182d6ec6f05393cc0e5ed1bf81ad6db3a8feedf8ee515ecdd369809bcce8082 \
    crate://crates.io/serde_yaml/0.8.26;sha256sum=578a7433b776b56a35785ed5ce9a7e777ac0598aac5a6dd1b4b18a307c7fc71b;serde_yaml-0.8.26.sha256sum=578a7433b776b56a35785ed5ce9a7e777ac0598aac5a6dd1b4b18a307c7fc71b \
    crate://crates.io/sha1/0.10.6;sha256sum=e3bf829a2d51ab4a5ddf1352d8470c140cadc8301b2ae1789db023f01cedd6ba;sha1-0.10.6.sha256sum=e3bf829a2d51ab4a5ddf1352d8470c140cadc8301b2ae1789db023f01cedd6ba \
    crate://crates.io/shlex/1.3.0;sha256sum=0fda2ff0d084019ba4d7c6f371c95d8fd75ce3524c3cb8fb653a3023f6323e64;shlex-1.3.0.sha256sum=0fda2ff0d084019ba4d7c6f371c95d8fd75ce3524c3cb8fb653a3023f6323e64 \
    crate://crates.io/signal-hook-registry/1.4.2;sha256sum=a9e9e0b4211b72e7b8b6e85c807d36c212bdb33ea8587f7569562a84df5465b1;signal-hook-registry-1.4.2.sha256sum=a9e9e0b4211b72e7b8b6e85c807d36c212bdb33ea8587f7569562a84df5465b1 \
    crate://crates.io/signal-hook/0.3.17;sha256sum=8621587d4798caf8eb44879d42e56b9a93ea5dcd315a6487c357130095b62801;signal-hook-0.3.17.sha256sum=8621587d4798caf8eb44879d42e56b9a93ea5dcd315a6487c357130095b62801 \
    crate://crates.io/slab/0.4.9;sha256sum=8f92a496fb766b417c996b9c5e57daf2f7ad3b0bebe1ccfca4856390e3d3bb67;slab-0.4.9.sha256sum=8f92a496fb766b417c996b9c5e57daf2f7ad3b0bebe1ccfca4856390e3d3bb67 \
    crate://crates.io/smallvec/1.13.2;sha256sum=3c5e1a9a646d36c3599cd173a41282daf47c44583ad367b8e6837255952e5c67;smallvec-1.13.2.sha256sum=3c5e1a9a646d36c3599cd173a41282daf47c44583ad367b8e6837255952e5c67 \
    crate://crates.io/socket2/0.4.10;sha256sum=9f7916fc008ca5542385b89a3d3ce689953c143e9304a9bf8beec1de48994c0d;socket2-0.4.10.sha256sum=9f7916fc008ca5542385b89a3d3ce689953c143e9304a9bf8beec1de48994c0d \
    crate://crates.io/static_assertions/1.1.0;sha256sum=a2eb9349b6444b326872e140eb1cf5e7c522154d69e7a0ffb0fb81c06b37543f;static_assertions-1.1.0.sha256sum=a2eb9349b6444b326872e140eb1cf5e7c522154d69e7a0ffb0fb81c06b37543f \
    crate://crates.io/stdweb/0.1.3;sha256sum=ef5430c8e36b713e13b48a9f709cc21e046723fe44ce34587b73a830203b533e;stdweb-0.1.3.sha256sum=ef5430c8e36b713e13b48a9f709cc21e046723fe44ce34587b73a830203b533e \
    crate://crates.io/strength_reduce/0.2.4;sha256sum=fe895eb47f22e2ddd4dabc02bce419d2e643c8e3b585c78158b349195bc24d82;strength_reduce-0.2.4.sha256sum=fe895eb47f22e2ddd4dabc02bce419d2e643c8e3b585c78158b349195bc24d82 \
    crate://crates.io/strsim/0.10.0;sha256sum=73473c0e59e6d5812c5dfe2a064a6444949f089e20eec9a2e5506596494e4623;strsim-0.10.0.sha256sum=73473c0e59e6d5812c5dfe2a064a6444949f089e20eec9a2e5506596494e4623 \
    crate://crates.io/strsim/0.8.0;sha256sum=8ea5119cdb4c55b55d432abb513a0429384878c15dde60cc77b1c99de1a95a6a;strsim-0.8.0.sha256sum=8ea5119cdb4c55b55d432abb513a0429384878c15dde60cc77b1c99de1a95a6a \
    crate://crates.io/syn/1.0.109;sha256sum=72b64191b275b66ffe2469e8af2c1cfe3bafa67b529ead792a6d0160888b4237;syn-1.0.109.sha256sum=72b64191b275b66ffe2469e8af2c1cfe3bafa67b529ead792a6d0160888b4237 \
    crate://crates.io/syn/2.0.76;sha256sum=578e081a14e0cefc3279b0472138c513f37b41a08d5a3cca9b6e4e8ceb6cd525;syn-2.0.76.sha256sum=578e081a14e0cefc3279b0472138c513f37b41a08d5a3cca9b6e4e8ceb6cd525 \
    crate://crates.io/tempfile/3.12.0;sha256sum=04cbcdd0c794ebb0d4cf35e88edd2f7d2c4c3e9a5a6dab322839b321c6a87a64;tempfile-3.12.0.sha256sum=04cbcdd0c794ebb0d4cf35e88edd2f7d2c4c3e9a5a6dab322839b321c6a87a64 \
    crate://crates.io/textwrap/0.11.0;sha256sum=d326610f408c7a4eb6f51c37c330e496b08506c9457c9d34287ecc38809fb060;textwrap-0.11.0.sha256sum=d326610f408c7a4eb6f51c37c330e496b08506c9457c9d34287ecc38809fb060 \
    crate://crates.io/thiserror-impl/1.0.63;sha256sum=a4558b58466b9ad7ca0f102865eccc95938dca1a74a856f2b57b6629050da261;thiserror-impl-1.0.63.sha256sum=a4558b58466b9ad7ca0f102865eccc95938dca1a74a856f2b57b6629050da261 \
    crate://crates.io/thiserror/1.0.63;sha256sum=c0342370b38b6a11b6cc11d6a805569958d54cfa061a29969c3b5ce2ea405724;thiserror-1.0.63.sha256sum=c0342370b38b6a11b6cc11d6a805569958d54cfa061a29969c3b5ce2ea405724 \
    crate://crates.io/thread-id/2.0.0;sha256sum=a9539db560102d1cef46b8b78ce737ff0bb64e7e18d35b2a5688f7d097d0ff03;thread-id-2.0.0.sha256sum=a9539db560102d1cef46b8b78ce737ff0bb64e7e18d35b2a5688f7d097d0ff03 \
    crate://crates.io/thread_local/0.2.7;sha256sum=8576dbbfcaef9641452d5cf0df9b0e7eeab7694956dd33bb61515fb8f18cfdd5;thread_local-0.2.7.sha256sum=8576dbbfcaef9641452d5cf0df9b0e7eeab7694956dd33bb61515fb8f18cfdd5 \
    crate://crates.io/time/0.1.45;sha256sum=1b797afad3f312d1c66a56d11d0316f916356d11bd158fbc6ca6389ff6bf805a;time-0.1.45.sha256sum=1b797afad3f312d1c66a56d11d0316f916356d11bd158fbc6ca6389ff6bf805a \
    crate://crates.io/tinytemplate/1.2.1;sha256sum=be4d6b5f19ff7664e8c98d03e2139cb510db9b0a60b55f8e8709b689d939b6bc;tinytemplate-1.2.1.sha256sum=be4d6b5f19ff7664e8c98d03e2139cb510db9b0a60b55f8e8709b689d939b6bc \
    crate://crates.io/tinyvec/1.8.0;sha256sum=445e881f4f6d382d5f27c034e25eb92edd7c784ceab92a0937db7f2e9471b938;tinyvec-1.8.0.sha256sum=445e881f4f6d382d5f27c034e25eb92edd7c784ceab92a0937db7f2e9471b938 \
    crate://crates.io/tinyvec_macros/0.1.1;sha256sum=1f3ccbac311fea05f86f61904b462b55fb3df8837a366dfc601a0161d0532f20;tinyvec_macros-0.1.1.sha256sum=1f3ccbac311fea05f86f61904b462b55fb3df8837a366dfc601a0161d0532f20 \
    crate://crates.io/toml_datetime/0.6.8;sha256sum=0dd7358ecb8fc2f8d014bf86f6f638ce72ba252a2c3a2572f2a795f1d23efb41;toml_datetime-0.6.8.sha256sum=0dd7358ecb8fc2f8d014bf86f6f638ce72ba252a2c3a2572f2a795f1d23efb41 \
    crate://crates.io/toml_edit/0.19.15;sha256sum=1b5bb770da30e5cbfde35a2d7b9b8a2c4b8ef89548a7a6aeab5c9a576e3e7421;toml_edit-0.19.15.sha256sum=1b5bb770da30e5cbfde35a2d7b9b8a2c4b8ef89548a7a6aeab5c9a576e3e7421 \
    crate://crates.io/tracing-attributes/0.1.27;sha256sum=34704c8d6ebcbc939824180af020566b01a7c01f80641264eba0999f6c2b6be7;tracing-attributes-0.1.27.sha256sum=34704c8d6ebcbc939824180af020566b01a7c01f80641264eba0999f6c2b6be7 \
    crate://crates.io/tracing-core/0.1.32;sha256sum=c06d3da6113f116aaee68e4d601191614c9053067f9ab7f6edbcb161237daa54;tracing-core-0.1.32.sha256sum=c06d3da6113f116aaee68e4d601191614c9053067f9ab7f6edbcb161237daa54 \
    crate://crates.io/tracing/0.1.40;sha256sum=c3523ab5a71916ccf420eebdf5521fcef02141234bbc0b8a49f2fdc4544364ef;tracing-0.1.40.sha256sum=c3523ab5a71916ccf420eebdf5521fcef02141234bbc0b8a49f2fdc4544364ef \
    crate://crates.io/transpose/0.2.3;sha256sum=1ad61aed86bc3faea4300c7aee358b4c6d0c8d6ccc36524c96e4c92ccf26e77e;transpose-0.2.3.sha256sum=1ad61aed86bc3faea4300c7aee358b4c6d0c8d6ccc36524c96e4c92ccf26e77e \
    crate://crates.io/tungstenite/0.21.0;sha256sum=9ef1a641ea34f399a848dea702823bbecfb4c486f911735368f1f137cb8257e1;tungstenite-0.21.0.sha256sum=9ef1a641ea34f399a848dea702823bbecfb4c486f911735368f1f137cb8257e1 \
    crate://crates.io/typenum/1.17.0;sha256sum=42ff0bf0c66b8238c6f3b578df37d0b7848e55df8577b3f74f92a69acceeb825;typenum-1.17.0.sha256sum=42ff0bf0c66b8238c6f3b578df37d0b7848e55df8577b3f74f92a69acceeb825 \
    crate://crates.io/uds_windows/1.1.0;sha256sum=89daebc3e6fd160ac4aa9fc8b3bf71e1f74fbf92367ae71fb83a037e8bf164b9;uds_windows-1.1.0.sha256sum=89daebc3e6fd160ac4aa9fc8b3bf71e1f74fbf92367ae71fb83a037e8bf164b9 \
    crate://crates.io/unicode-bidi/0.3.15;sha256sum=08f95100a766bf4f8f28f90d77e0a5461bbdb219042e7679bebe79004fed8d75;unicode-bidi-0.3.15.sha256sum=08f95100a766bf4f8f28f90d77e0a5461bbdb219042e7679bebe79004fed8d75 \
    crate://crates.io/unicode-ident/1.0.12;sha256sum=3354b9ac3fae1ff6755cb6db53683adb661634f67557942dea4facebec0fee4b;unicode-ident-1.0.12.sha256sum=3354b9ac3fae1ff6755cb6db53683adb661634f67557942dea4facebec0fee4b \
    crate://crates.io/unicode-normalization/0.1.23;sha256sum=a56d1686db2308d901306f92a263857ef59ea39678a5458e7cb17f01415101f5;unicode-normalization-0.1.23.sha256sum=a56d1686db2308d901306f92a263857ef59ea39678a5458e7cb17f01415101f5 \
    crate://crates.io/unicode-width/0.1.13;sha256sum=0336d538f7abc86d282a4189614dfaa90810dfc2c6f6427eaf88e16311dd225d;unicode-width-0.1.13.sha256sum=0336d538f7abc86d282a4189614dfaa90810dfc2c6f6427eaf88e16311dd225d \
    crate://crates.io/url/2.5.2;sha256sum=22784dbdf76fdde8af1aeda5622b546b422b6fc585325248a2bf9f5e41e94d6c;url-2.5.2.sha256sum=22784dbdf76fdde8af1aeda5622b546b422b6fc585325248a2bf9f5e41e94d6c \
    crate://crates.io/utf-8/0.7.6;sha256sum=09cc8ee72d2a9becf2f2febe0205bbed8fc6615b7cb429ad062dc7b7ddd036a9;utf-8-0.7.6.sha256sum=09cc8ee72d2a9becf2f2febe0205bbed8fc6615b7cb429ad062dc7b7ddd036a9 \
    crate://crates.io/utf8-ranges/0.1.3;sha256sum=a1ca13c08c41c9c3e04224ed9ff80461d97e121589ff27c753a16cb10830ae0f;utf8-ranges-0.1.3.sha256sum=a1ca13c08c41c9c3e04224ed9ff80461d97e121589ff27c753a16cb10830ae0f \
    crate://crates.io/vcpkg/0.2.15;sha256sum=accd4ea62f7bb7a82fe23066fb0957d48ef677f6eeb8215f372f52e48bb32426;vcpkg-0.2.15.sha256sum=accd4ea62f7bb7a82fe23066fb0957d48ef677f6eeb8215f372f52e48bb32426 \
    crate://crates.io/vec_map/0.8.2;sha256sum=f1bddf1187be692e79c5ffeab891132dfb0f236ed36a43c7ed39f1165ee20191;vec_map-0.8.2.sha256sum=f1bddf1187be692e79c5ffeab891132dfb0f236ed36a43c7ed39f1165ee20191 \
    crate://crates.io/version_check/0.9.5;sha256sum=0b928f33d975fc6ad9f86c8f283853ad26bdd5b10b7f1542aa2fa15e2289105a;version_check-0.9.5.sha256sum=0b928f33d975fc6ad9f86c8f283853ad26bdd5b10b7f1542aa2fa15e2289105a \
    crate://crates.io/waker-fn/1.2.0;sha256sum=317211a0dc0ceedd78fb2ca9a44aed3d7b9b26f81870d485c07122b4350673b7;waker-fn-1.2.0.sha256sum=317211a0dc0ceedd78fb2ca9a44aed3d7b9b26f81870d485c07122b4350673b7 \
    crate://crates.io/walkdir/2.5.0;sha256sum=29790946404f91d9c5d06f9874efddea1dc06c5efe94541a7d6863108e3a5e4b;walkdir-2.5.0.sha256sum=29790946404f91d9c5d06f9874efddea1dc06c5efe94541a7d6863108e3a5e4b \
    crate://crates.io/wasapi/0.13.0;sha256sum=98543fc2da45ebfa9c15641c7f7f28020c814c7da7ab8470b72b37219ea92139;wasapi-0.13.0.sha256sum=98543fc2da45ebfa9c15641c7f7f28020c814c7da7ab8470b72b37219ea92139 \
    crate://crates.io/wasi/0.10.0+wasi-snapshot-preview1;sha256sum=1a143597ca7c7793eff794def352d41792a93c481eb1042423ff7ff72ba2c31f;wasi-0.10.0+wasi-snapshot-preview1.sha256sum=1a143597ca7c7793eff794def352d41792a93c481eb1042423ff7ff72ba2c31f \
    crate://crates.io/wasi/0.11.0+wasi-snapshot-preview1;sha256sum=9c8d87e72b64a3b4db28d11ce29237c246188f4f51057d65a7eab63b7987e423;wasi-0.11.0+wasi-snapshot-preview1.sha256sum=9c8d87e72b64a3b4db28d11ce29237c246188f4f51057d65a7eab63b7987e423 \
    crate://crates.io/wasm-bindgen-backend/0.2.93;sha256sum=9de396da306523044d3302746f1208fa71d7532227f15e347e2d93e4145dd77b;wasm-bindgen-backend-0.2.93.sha256sum=9de396da306523044d3302746f1208fa71d7532227f15e347e2d93e4145dd77b \
    crate://crates.io/wasm-bindgen-macro-support/0.2.93;sha256sum=afc340c74d9005395cf9dd098506f7f44e38f2b4a21c6aaacf9a105ea5e1e836;wasm-bindgen-macro-support-0.2.93.sha256sum=afc340c74d9005395cf9dd098506f7f44e38f2b4a21c6aaacf9a105ea5e1e836 \
    crate://crates.io/wasm-bindgen-macro/0.2.93;sha256sum=585c4c91a46b072c92e908d99cb1dcdf95c5218eeb6f3bf1efa991ee7a68cccf;wasm-bindgen-macro-0.2.93.sha256sum=585c4c91a46b072c92e908d99cb1dcdf95c5218eeb6f3bf1efa991ee7a68cccf \
    crate://crates.io/wasm-bindgen-shared/0.2.93;sha256sum=c62a0a307cb4a311d3a07867860911ca130c3494e8c2719593806c08bc5d0484;wasm-bindgen-shared-0.2.93.sha256sum=c62a0a307cb4a311d3a07867860911ca130c3494e8c2719593806c08bc5d0484 \
    crate://crates.io/wasm-bindgen/0.2.93;sha256sum=a82edfc16a6c469f5f44dc7b571814045d60404b55a0ee849f9bcfa2e63dd9b5;wasm-bindgen-0.2.93.sha256sum=a82edfc16a6c469f5f44dc7b571814045d60404b55a0ee849f9bcfa2e63dd9b5 \
    crate://crates.io/web-sys/0.3.70;sha256sum=26fdeaafd9bd129f65e7c031593c24d62186301e0c72c8978fa1678be7d532c0;web-sys-0.3.70.sha256sum=26fdeaafd9bd129f65e7c031593c24d62186301e0c72c8978fa1678be7d532c0 \
    crate://crates.io/widestring/1.1.0;sha256sum=7219d36b6eac893fa81e84ebe06485e7dcbb616177469b142df14f1f4deb1311;widestring-1.1.0.sha256sum=7219d36b6eac893fa81e84ebe06485e7dcbb616177469b142df14f1f4deb1311 \
    crate://crates.io/winapi-build/0.1.1;sha256sum=2d315eee3b34aca4797b2da6b13ed88266e6d612562a0c46390af8299fc699bc;winapi-build-0.1.1.sha256sum=2d315eee3b34aca4797b2da6b13ed88266e6d612562a0c46390af8299fc699bc \
    crate://crates.io/winapi-i686-pc-windows-gnu/0.4.0;sha256sum=ac3b87c63620426dd9b991e5ce0329eff545bccbbb34f3be09ff6fb6ab51b7b6;winapi-i686-pc-windows-gnu-0.4.0.sha256sum=ac3b87c63620426dd9b991e5ce0329eff545bccbbb34f3be09ff6fb6ab51b7b6 \
    crate://crates.io/winapi-util/0.1.9;sha256sum=cf221c93e13a30d793f7645a0e7762c55d169dbb0a49671918a2319d289b10bb;winapi-util-0.1.9.sha256sum=cf221c93e13a30d793f7645a0e7762c55d169dbb0a49671918a2319d289b10bb \
    crate://crates.io/winapi-x86_64-pc-windows-gnu/0.4.0;sha256sum=712e227841d057c1ee1cd2fb22fa7e5a5461ae8e48fa2ca79ec42cfc1931183f;winapi-x86_64-pc-windows-gnu-0.4.0.sha256sum=712e227841d057c1ee1cd2fb22fa7e5a5461ae8e48fa2ca79ec42cfc1931183f \
    crate://crates.io/winapi/0.2.8;sha256sum=167dc9d6949a9b857f3451275e911c3f44255842c1f7a76f33c55103a909087a;winapi-0.2.8.sha256sum=167dc9d6949a9b857f3451275e911c3f44255842c1f7a76f33c55103a909087a \
    crate://crates.io/winapi/0.3.9;sha256sum=5c839a674fcd7a98952e593242ea400abe93992746761e38641405d28b00f419;winapi-0.3.9.sha256sum=5c839a674fcd7a98952e593242ea400abe93992746761e38641405d28b00f419 \
    crate://crates.io/windows-core/0.52.0;sha256sum=33ab640c8d7e35bf8ba19b884ba838ceb4fba93a4e8c65a9059d08afcfc683d9;windows-core-0.52.0.sha256sum=33ab640c8d7e35bf8ba19b884ba838ceb4fba93a4e8c65a9059d08afcfc683d9 \
    crate://crates.io/windows-implement/0.48.0;sha256sum=5e2ee588991b9e7e6c8338edf3333fbe4da35dc72092643958ebb43f0ab2c49c;windows-implement-0.48.0.sha256sum=5e2ee588991b9e7e6c8338edf3333fbe4da35dc72092643958ebb43f0ab2c49c \
    crate://crates.io/windows-interface/0.48.0;sha256sum=e6fb8df20c9bcaa8ad6ab513f7b40104840c8867d5751126e4df3b08388d0cc7;windows-interface-0.48.0.sha256sum=e6fb8df20c9bcaa8ad6ab513f7b40104840c8867d5751126e4df3b08388d0cc7 \
    crate://crates.io/windows-sys/0.48.0;sha256sum=677d2418bec65e3338edb076e806bc1ec15693c5d0104683f2efe857f61056a9;windows-sys-0.48.0.sha256sum=677d2418bec65e3338edb076e806bc1ec15693c5d0104683f2efe857f61056a9 \
    crate://crates.io/windows-sys/0.52.0;sha256sum=282be5f36a8ce781fad8c8ae18fa3f9beff57ec1b52cb3de0789201425d9a33d;windows-sys-0.52.0.sha256sum=282be5f36a8ce781fad8c8ae18fa3f9beff57ec1b52cb3de0789201425d9a33d \
    crate://crates.io/windows-sys/0.59.0;sha256sum=1e38bc4d79ed67fd075bcc251a1c39b32a1776bbe92e5bef1f0bf1f8c531853b;windows-sys-0.59.0.sha256sum=1e38bc4d79ed67fd075bcc251a1c39b32a1776bbe92e5bef1f0bf1f8c531853b \
    crate://crates.io/windows-targets/0.48.5;sha256sum=9a2fa6e2155d7247be68c096456083145c183cbbbc2764150dda45a87197940c;windows-targets-0.48.5.sha256sum=9a2fa6e2155d7247be68c096456083145c183cbbbc2764150dda45a87197940c \
    crate://crates.io/windows-targets/0.52.6;sha256sum=9b724f72796e036ab90c1021d4780d4d3d648aca59e491e6b98e725b84e99973;windows-targets-0.52.6.sha256sum=9b724f72796e036ab90c1021d4780d4d3d648aca59e491e6b98e725b84e99973 \
    crate://crates.io/windows/0.48.0;sha256sum=e686886bc078bc1b0b600cac0147aadb815089b6e4da64016cbd754b6342700f;windows-0.48.0.sha256sum=e686886bc078bc1b0b600cac0147aadb815089b6e4da64016cbd754b6342700f \
    crate://crates.io/windows_aarch64_gnullvm/0.48.5;sha256sum=2b38e32f0abccf9987a4e3079dfb67dcd799fb61361e53e2882c3cbaf0d905d8;windows_aarch64_gnullvm-0.48.5.sha256sum=2b38e32f0abccf9987a4e3079dfb67dcd799fb61361e53e2882c3cbaf0d905d8 \
    crate://crates.io/windows_aarch64_gnullvm/0.52.6;sha256sum=32a4622180e7a0ec044bb555404c800bc9fd9ec262ec147edd5989ccd0c02cd3;windows_aarch64_gnullvm-0.52.6.sha256sum=32a4622180e7a0ec044bb555404c800bc9fd9ec262ec147edd5989ccd0c02cd3 \
    crate://crates.io/windows_aarch64_msvc/0.48.5;sha256sum=dc35310971f3b2dbbf3f0690a219f40e2d9afcf64f9ab7cc1be722937c26b4bc;windows_aarch64_msvc-0.48.5.sha256sum=dc35310971f3b2dbbf3f0690a219f40e2d9afcf64f9ab7cc1be722937c26b4bc \
    crate://crates.io/windows_aarch64_msvc/0.52.6;sha256sum=09ec2a7bb152e2252b53fa7803150007879548bc709c039df7627cabbd05d469;windows_aarch64_msvc-0.52.6.sha256sum=09ec2a7bb152e2252b53fa7803150007879548bc709c039df7627cabbd05d469 \
    crate://crates.io/windows_i686_gnu/0.48.5;sha256sum=a75915e7def60c94dcef72200b9a8e58e5091744960da64ec734a6c6e9b3743e;windows_i686_gnu-0.48.5.sha256sum=a75915e7def60c94dcef72200b9a8e58e5091744960da64ec734a6c6e9b3743e \
    crate://crates.io/windows_i686_gnu/0.52.6;sha256sum=8e9b5ad5ab802e97eb8e295ac6720e509ee4c243f69d781394014ebfe8bbfa0b;windows_i686_gnu-0.52.6.sha256sum=8e9b5ad5ab802e97eb8e295ac6720e509ee4c243f69d781394014ebfe8bbfa0b \
    crate://crates.io/windows_i686_gnullvm/0.52.6;sha256sum=0eee52d38c090b3caa76c563b86c3a4bd71ef1a819287c19d586d7334ae8ed66;windows_i686_gnullvm-0.52.6.sha256sum=0eee52d38c090b3caa76c563b86c3a4bd71ef1a819287c19d586d7334ae8ed66 \
    crate://crates.io/windows_i686_msvc/0.48.5;sha256sum=8f55c233f70c4b27f66c523580f78f1004e8b5a8b659e05a4eb49d4166cca406;windows_i686_msvc-0.48.5.sha256sum=8f55c233f70c4b27f66c523580f78f1004e8b5a8b659e05a4eb49d4166cca406 \
    crate://crates.io/windows_i686_msvc/0.52.6;sha256sum=240948bc05c5e7c6dabba28bf89d89ffce3e303022809e73deaefe4f6ec56c66;windows_i686_msvc-0.52.6.sha256sum=240948bc05c5e7c6dabba28bf89d89ffce3e303022809e73deaefe4f6ec56c66 \
    crate://crates.io/windows_x86_64_gnu/0.48.5;sha256sum=53d40abd2583d23e4718fddf1ebec84dbff8381c07cae67ff7768bbf19c6718e;windows_x86_64_gnu-0.48.5.sha256sum=53d40abd2583d23e4718fddf1ebec84dbff8381c07cae67ff7768bbf19c6718e \
    crate://crates.io/windows_x86_64_gnu/0.52.6;sha256sum=147a5c80aabfbf0c7d901cb5895d1de30ef2907eb21fbbab29ca94c5b08b1a78;windows_x86_64_gnu-0.52.6.sha256sum=147a5c80aabfbf0c7d901cb5895d1de30ef2907eb21fbbab29ca94c5b08b1a78 \
    crate://crates.io/windows_x86_64_gnullvm/0.48.5;sha256sum=0b7b52767868a23d5bab768e390dc5f5c55825b6d30b86c844ff2dc7414044cc;windows_x86_64_gnullvm-0.48.5.sha256sum=0b7b52767868a23d5bab768e390dc5f5c55825b6d30b86c844ff2dc7414044cc \
    crate://crates.io/windows_x86_64_gnullvm/0.52.6;sha256sum=24d5b23dc417412679681396f2b49f3de8c1473deb516bd34410872eff51ed0d;windows_x86_64_gnullvm-0.52.6.sha256sum=24d5b23dc417412679681396f2b49f3de8c1473deb516bd34410872eff51ed0d \
    crate://crates.io/windows_x86_64_msvc/0.48.5;sha256sum=ed94fce61571a4006852b7389a063ab983c02eb1bb37b47f8272ce92d06d9538;windows_x86_64_msvc-0.48.5.sha256sum=ed94fce61571a4006852b7389a063ab983c02eb1bb37b47f8272ce92d06d9538 \
    crate://crates.io/windows_x86_64_msvc/0.52.6;sha256sum=589f6da84c646204747d1270a2a5661ea66ed1cced2631d546fdfb155959f9ec;windows_x86_64_msvc-0.52.6.sha256sum=589f6da84c646204747d1270a2a5661ea66ed1cced2631d546fdfb155959f9ec \
    crate://crates.io/winnow/0.5.40;sha256sum=f593a95398737aeed53e489c785df13f3618e41dbcd6718c6addbf1395aa6876;winnow-0.5.40.sha256sum=f593a95398737aeed53e489c785df13f3618e41dbcd6718c6addbf1395aa6876 \
    crate://crates.io/xdg-home/1.3.0;sha256sum=ec1cdab258fb55c0da61328dc52c8764709b249011b2cad0454c72f0bf10a1f6;xdg-home-1.3.0.sha256sum=ec1cdab258fb55c0da61328dc52c8764709b249011b2cad0454c72f0bf10a1f6 \
    crate://crates.io/yaml-rust/0.4.5;sha256sum=56c1936c4cc7a1c9ab21a1ebb602eb942ba868cbd44a99cb7cdc5892335e1c85;yaml-rust-0.4.5.sha256sum=56c1936c4cc7a1c9ab21a1ebb602eb942ba868cbd44a99cb7cdc5892335e1c85 \
    crate://crates.io/zbus/3.15.2;sha256sum=675d170b632a6ad49804c8cf2105d7c31eddd3312555cffd4b740e08e97c25e6;zbus-3.15.2.sha256sum=675d170b632a6ad49804c8cf2105d7c31eddd3312555cffd4b740e08e97c25e6 \
    crate://crates.io/zbus_macros/3.15.2;sha256sum=7131497b0f887e8061b430c530240063d33bf9455fa34438f388a245da69e0a5;zbus_macros-3.15.2.sha256sum=7131497b0f887e8061b430c530240063d33bf9455fa34438f388a245da69e0a5 \
    crate://crates.io/zbus_names/2.6.1;sha256sum=437d738d3750bed6ca9b8d423ccc7a8eb284f6b1d6d4e225a0e4e6258d864c8d;zbus_names-2.6.1.sha256sum=437d738d3750bed6ca9b8d423ccc7a8eb284f6b1d6d4e225a0e4e6258d864c8d \
    crate://crates.io/zerocopy-derive/0.7.35;sha256sum=fa4f8080344d4671fb4e831a13ad1e68092748387dfc4f55e356242fae12ce3e;zerocopy-derive-0.7.35.sha256sum=fa4f8080344d4671fb4e831a13ad1e68092748387dfc4f55e356242fae12ce3e \
    crate://crates.io/zerocopy/0.7.35;sha256sum=1b9b4fd18abc82b8136838da5d50bae7bdea537c574d8dc1a34ed098d6c166f0;zerocopy-0.7.35.sha256sum=1b9b4fd18abc82b8136838da5d50bae7bdea537c574d8dc1a34ed098d6c166f0 \
    crate://crates.io/zip/0.5.13;sha256sum=93ab48844d61251bb3835145c521d88aa4031d7139e8485990f60ca911fa0815;zip-0.5.13.sha256sum=93ab48844d61251bb3835145c521d88aa4031d7139e8485990f60ca911fa0815 \
    crate://crates.io/zvariant/3.15.2;sha256sum=4eef2be88ba09b358d3b58aca6e41cd853631d44787f319a1383ca83424fb2db;zvariant-3.15.2.sha256sum=4eef2be88ba09b358d3b58aca6e41cd853631d44787f319a1383ca83424fb2db \
    crate://crates.io/zvariant_derive/3.15.2;sha256sum=37c24dc0bed72f5f90d1f8bb5b07228cbf63b3c6e9f82d82559d4bae666e7ed9;zvariant_derive-3.15.2.sha256sum=37c24dc0bed72f5f90d1f8bb5b07228cbf63b3c6e9f82d82559d4bae666e7ed9 \
    crate://crates.io/zvariant_utils/1.0.1;sha256sum=7234f0d811589db492d16893e3f21e8e2fd282e6d01b0cddee310322062cc200;zvariant_utils-1.0.1.sha256sum=7234f0d811589db492d16893e3f21e8e2fd282e6d01b0cddee310322062cc200 \
"



# FIXME: update generateme with the real MD5 of the license file
LIC_FILES_CHKSUM = " \
    file://LICENSE.txt;md5=1ebbd3e34237af26da5dc08a4e440464 \
"

SUMMARY = "A flexible tool for processing audio"
HOMEPAGE = "https://github.com/HEnquist/camilladsp"
LICENSE = "GPL-3.0-only"

# includes this file if it exists but does not fail
# this is useful for anything you may want to override from
# what cargo-bitbake generates.
include camilladsp-${PV}.inc
include camilladsp.inc
